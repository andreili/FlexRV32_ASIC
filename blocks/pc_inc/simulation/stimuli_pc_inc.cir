**************************************
* SPICE STIMULI FILE
* generated from
**************************************

VA[12] A[12] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[13] A[13] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[14] A[14] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[0] A[0] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[15] A[15] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[20] A[20] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[1] A[1] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[16] A[16] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[21] A[21] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[2] A[2] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[17] A[17] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[22] A[22] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[3] A[3] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[18] A[18] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[23] A[23] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[4] A[4] 0 PWL 0n 0 2n 0 2.1n {VCC}
VA[19] A[19] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[24] A[24] 0 PWL 0n 0 6n 0 6.1n {VCC}
Vis_comp_n is_comp_n 0 PWL 0n {VCC} 4n {VCC} 4.1n 0 10n 0 10.1n {VCC}
VA[5] A[5] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[25] A[25] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[30] A[30] 0 PWL 0n 0
VA[6] A[6] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[26] A[26] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[31] A[31] 0 PWL 0n 0
Vis_comp_p is_comp_p 0 PWL 0n 0 4n 0 4.1n {VCC} 10n {VCC} 10.1n 0
VA[7] A[7] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[27] A[27] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[8] A[8] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[10] A[10] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[28] A[28] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[9] A[9] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[11] A[11] 0 PWL 0n 0 6n 0 6.1n {VCC}
VA[29] A[29] 0 PWL 0n 0
