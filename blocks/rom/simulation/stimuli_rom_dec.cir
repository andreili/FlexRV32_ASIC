**************************************
* SPICE STIMULI FILE
* generated from
**************************************

VA[0] A[0] 0 PWL 1n 0
VA[1] A[1] 0 PWL 1n 0
VA[2] A[2] 0 PWL 1n 0 2n 0 2.025n {VCC} 3n {VCC} 3.025n 0 4n
+0 4.025n {VCC} 6n {VCC} 6.025n 0 7n 0 7.025n {VCC} 8n {VCC} 8.025n 0
+9n 0 9.025n {VCC} 10n {VCC} 10.025n 0 11n 0 11.025n {VCC} 12n {VCC} 12.025n
+0 13n 0 13.025n {VCC} 14n {VCC} 14.025n 0 15n 0 15.025n {VCC} 16n {VCC}
+16.025n 0 17n 0 17.025n {VCC} 18n {VCC} 18.025n 0 19n 0 19.025n {VCC} 20n
+{VCC} 20.025n 0 21n 0 21.025n {VCC} 22n {VCC} 22.025n 0 23n 0 23.025n {VCC}
+24n {VCC} 24.025n 0 25n 0 25.025n {VCC} 26n {VCC} 26.025n 0 27n 0 27.025n
+{VCC} 28n {VCC} 28.025n 0 29n 0 29.025n {VCC} 30n {VCC} 30.025n 0 31n 0
+31.025n {VCC} 32n {VCC} 32.025n 0 33n 0 33.025n {VCC} 34n {VCC} 34.025n 0 35n
+0 35.025n {VCC} 36n {VCC} 36.025n 0 37n 0 37.025n {VCC} 38n {VCC} 38.025n 0
+39n 0 39.025n {VCC} 40n {VCC} 40.025n 0 41n 0 41.025n {VCC} 42n {VCC} 42.025n
+0 43n 0 43.025n {VCC} 44n {VCC} 44.025n 0 45n 0 45.025n {VCC} 46n {VCC}
+46.025n 0 47n 0 47.025n {VCC} 48n {VCC} 48.025n 0 49n 0 49.025n {VCC} 50n
+{VCC} 50.025n 0 51n 0 51.025n {VCC} 52n {VCC} 52.025n 0 53n 0 53.025n {VCC}
+54n {VCC} 54.025n 0 55n 0 55.025n {VCC} 56n {VCC} 56.025n 0 57n 0 57.025n
+{VCC} 58n {VCC} 58.025n 0 59n 0 59.025n {VCC} 60n {VCC} 60.025n 0 61n 0
+61.025n {VCC} 62n {VCC} 62.025n 0 63n 0 63.025n {VCC} 64n {VCC} 64.025n 0 65n
+0 65.025n {VCC} 66n {VCC} 66.025n 0 67n 0 67.025n {VCC} 68n {VCC} 68.025n 0
+69n 0 69.025n {VCC} 70n {VCC} 70.025n 0 71n 0 71.025n {VCC} 72n {VCC} 72.025n
+0 73n 0 73.025n {VCC} 74n {VCC} 74.025n 0 75n 0 75.025n {VCC} 76n {VCC}
+76.025n 0 77n 0 77.025n {VCC} 78n {VCC} 78.025n 0 79n 0 79.025n {VCC} 80n
+{VCC} 80.025n 0 81n 0 81.025n {VCC} 82n {VCC} 82.025n 0 83n 0 83.025n {VCC}
+84n {VCC} 84.025n 0 85n 0 85.025n {VCC} 86n {VCC} 86.025n 0 87n 0 87.025n
+{VCC} 88n {VCC} 88.025n 0 89n 0 89.025n {VCC} 90n {VCC} 90.025n 0 91n 0
+91.025n {VCC} 92n {VCC} 92.025n 0 93n 0 93.025n {VCC} 94n {VCC} 94.025n 0 95n
+0 95.025n {VCC} 96n {VCC} 96.025n 0 97n 0 97.025n {VCC} 98n {VCC} 98.025n 0
+99n 0 99.025n {VCC} 100n {VCC} 100.025n 0 101n 0 101.025n {VCC} 102n {VCC} 102.025n
+0 103n 0 103.025n {VCC} 104n {VCC} 104.025n 0 105n 0 105.025n {VCC} 106n {VCC}
+106.025n 0 107n 0 107.025n {VCC} 108n {VCC} 108.025n 0 109n 0 109.025n {VCC} 110n
+{VCC} 110.025n 0 111n 0 111.025n {VCC} 112n {VCC} 112.025n 0 113n 0 113.025n {VCC}
+114n {VCC} 114.025n 0 115n 0 115.025n {VCC} 116n {VCC} 116.025n 0 117n 0 117.025n
+{VCC} 118n {VCC} 118.025n 0 119n 0 119.025n {VCC} 120n {VCC} 120.025n 0 121n 0
+121.025n {VCC} 122n {VCC} 122.025n 0 123n 0 123.025n {VCC} 124n {VCC} 124.025n 0 125n
+0 125.025n {VCC} 126n {VCC} 126.025n 0 127n 0 127.025n {VCC} 128n {VCC} 128.025n 0
+129n 0 129.025n {VCC} 130n {VCC} 130.025n 0 131n 0 131.025n {VCC} 132n {VCC} 132.025n
+0 133n 0 133.025n {VCC} 134n {VCC} 134.025n 0 135n 0 135.025n {VCC} 136n {VCC}
+136.025n 0 137n 0 137.025n {VCC} 138n {VCC} 138.025n 0 139n 0 139.025n {VCC} 140n
+{VCC} 140.025n 0 141n 0 141.025n {VCC} 142n {VCC} 142.025n 0 143n 0 143.025n {VCC}
+144n {VCC} 144.025n 0 145n 0 145.025n {VCC} 146n {VCC} 146.025n 0 147n 0 147.025n
+{VCC} 148n {VCC} 148.025n 0 149n 0 149.025n {VCC} 150n {VCC} 150.025n 0 151n 0
+151.025n {VCC} 152n {VCC} 152.025n 0 153n 0 153.025n {VCC} 154n {VCC} 154.025n 0 155n
+0 155.025n {VCC} 156n {VCC} 156.025n 0 157n 0 157.025n {VCC} 158n {VCC} 158.025n 0
+159n 0 159.025n {VCC} 160n {VCC} 160.025n 0 161n 0 161.025n {VCC} 162n {VCC} 162.025n
+0 163n 0 163.025n {VCC} 164n {VCC} 164.025n 0 165n 0 165.025n {VCC} 166n {VCC}
+166.025n 0 167n 0 167.025n {VCC} 168n {VCC} 168.025n 0 169n 0 169.025n {VCC} 170n
+{VCC} 170.025n 0 171n 0 171.025n {VCC} 172n {VCC} 172.025n 0 173n 0 173.025n {VCC}
+174n {VCC} 174.025n 0 175n 0 175.025n {VCC} 176n {VCC} 176.025n 0 177n 0 177.025n
+{VCC} 178n {VCC} 178.025n 0 179n 0 179.025n {VCC} 180n {VCC} 180.025n 0 181n 0
+181.025n {VCC} 182n {VCC} 182.025n 0 183n 0 183.025n {VCC} 184n {VCC} 184.025n 0 185n
+0 185.025n {VCC} 186n {VCC} 186.025n 0 187n 0 187.025n {VCC} 188n {VCC} 188.025n 0
+189n 0 189.025n {VCC} 190n {VCC} 190.025n 0 191n 0 191.025n {VCC} 192n {VCC} 192.025n
+0 193n 0 193.025n {VCC} 194n {VCC} 194.025n 0 195n 0 195.025n {VCC} 196n {VCC}
+196.025n 0 197n 0 197.025n {VCC} 198n {VCC} 198.025n 0 199n 0 199.025n {VCC} 200n
+{VCC} 200.025n 0 201n 0 201.025n {VCC} 202n {VCC} 202.025n 0 203n 0 203.025n {VCC}
+204n {VCC} 204.025n 0 205n 0 205.025n {VCC} 206n {VCC} 206.025n 0 207n 0 207.025n
+{VCC} 208n {VCC} 208.025n 0 209n 0 209.025n {VCC} 210n {VCC} 210.025n 0 211n 0
+211.025n {VCC} 212n {VCC} 212.025n 0 213n 0 213.025n {VCC} 214n {VCC} 214.025n 0 215n
+0 215.025n {VCC} 216n {VCC} 216.025n 0 217n 0 217.025n {VCC} 218n {VCC} 218.025n 0
+219n 0 219.025n {VCC} 220n {VCC} 220.025n 0 221n 0 221.025n {VCC} 222n {VCC} 222.025n
+0 223n 0 223.025n {VCC} 224n {VCC} 224.025n 0 225n 0 225.025n {VCC} 226n {VCC}
+226.025n 0 227n 0 227.025n {VCC} 228n {VCC} 228.025n 0 229n 0 229.025n {VCC} 230n
+{VCC} 230.025n 0 231n 0 231.025n {VCC} 232n {VCC} 232.025n 0 233n 0 233.025n {VCC}
+234n {VCC} 234.025n 0 235n 0 235.025n {VCC} 236n {VCC} 236.025n 0 237n 0 237.025n
+{VCC} 238n {VCC} 238.025n 0 239n 0 239.025n {VCC} 240n {VCC} 240.025n 0 241n 0
+241.025n {VCC} 242n {VCC} 242.025n 0 243n 0 243.025n {VCC} 244n {VCC} 244.025n 0 245n
+0 245.025n {VCC} 246n {VCC} 246.025n 0 247n 0 247.025n {VCC} 248n {VCC} 248.025n 0
+249n 0 249.025n {VCC} 250n {VCC} 250.025n 0 251n 0 251.025n {VCC} 252n {VCC} 252.025n
+0 253n 0 253.025n {VCC} 254n {VCC} 254.025n 0 255n 0 255.025n {VCC} 256n {VCC}
+256.025n 0 257n 0 257.025n {VCC} 258n {VCC} 258.025n 0 259n 0 259.025n {VCC} 260n
+{VCC} 260.025n 0 261n 0 261.025n {VCC} 262n {VCC} 262.025n 0 263n 0 263.025n {VCC}
+264n {VCC} 264.025n 0 265n 0 265.025n {VCC} 266n {VCC} 266.025n 0 267n 0 267.025n
+{VCC} 268n {VCC} 268.025n 0 269n 0 269.025n {VCC} 270n {VCC} 270.025n 0 271n 0
+271.025n {VCC} 272n {VCC} 272.025n 0 273n 0 273.025n {VCC} 274n {VCC} 274.025n 0 275n
+0 275.025n {VCC} 276n {VCC} 276.025n 0 277n 0 277.025n {VCC} 278n {VCC} 278.025n 0
+279n 0 279.025n {VCC} 280n {VCC} 280.025n 0 281n 0 281.025n {VCC} 282n {VCC} 282.025n
+0 283n 0 283.025n {VCC} 284n {VCC} 284.025n 0 285n 0 285.025n {VCC} 286n {VCC}
+286.025n 0 287n 0 287.025n {VCC} 288n {VCC} 288.025n 0 289n 0 289.025n {VCC} 290n
+{VCC} 290.025n 0 291n 0 291.025n {VCC} 292n {VCC} 292.025n 0 293n 0 293.025n {VCC}
+294n {VCC} 294.025n 0 295n 0 295.025n {VCC} 296n {VCC} 296.025n 0 297n 0 297.025n
+{VCC} 298n {VCC} 298.025n 0 299n 0 299.025n {VCC} 300n {VCC} 300.025n 0 301n 0
+301.025n {VCC} 302n {VCC} 302.025n 0 303n 0 303.025n {VCC} 304n {VCC} 304.025n 0 305n
+0 305.025n {VCC} 306n {VCC} 306.025n 0 307n 0 307.025n {VCC} 308n {VCC} 308.025n 0
+309n 0 309.025n {VCC} 310n {VCC} 310.025n 0 311n 0 311.025n {VCC} 312n {VCC} 312.025n
+0 313n 0 313.025n {VCC} 314n {VCC} 314.025n 0 315n 0 315.025n {VCC} 316n {VCC}
+316.025n 0 317n 0 317.025n {VCC} 318n {VCC} 318.025n 0 319n 0 319.025n {VCC} 320n
+{VCC} 320.025n 0 321n 0 321.025n {VCC} 322n {VCC} 322.025n 0 323n 0 323.025n {VCC}
+324n {VCC} 324.025n 0 325n 0 325.025n {VCC} 326n {VCC} 326.025n 0 327n 0 327.025n
+{VCC} 328n {VCC} 328.025n 0 329n 0 329.025n {VCC} 330n {VCC} 330.025n 0 331n 0
+331.025n {VCC} 332n {VCC} 332.025n 0 333n 0 333.025n {VCC} 334n {VCC} 334.025n 0 335n
+0 335.025n {VCC} 336n {VCC} 336.025n 0 337n 0 337.025n {VCC} 338n {VCC} 338.025n 0
+339n 0 339.025n {VCC} 340n {VCC} 340.025n 0 341n 0 341.025n {VCC} 342n {VCC} 342.025n
+0 343n 0 343.025n {VCC} 344n {VCC} 344.025n 0 345n 0 345.025n {VCC} 346n {VCC}
+346.025n 0 347n 0 347.025n {VCC} 348n {VCC} 348.025n 0 349n 0 349.025n {VCC} 350n
+{VCC} 350.025n 0 351n 0 351.025n {VCC} 352n {VCC} 352.025n 0 353n 0 353.025n {VCC}
+354n {VCC} 354.025n 0 355n 0 355.025n {VCC} 356n {VCC} 356.025n 0 357n 0 357.025n
+{VCC} 358n {VCC} 358.025n 0 359n 0 359.025n {VCC} 360n {VCC} 360.025n 0 361n 0
+361.025n {VCC} 362n {VCC} 362.025n 0 363n 0 363.025n {VCC} 364n {VCC} 364.025n 0 365n
+0 365.025n {VCC} 366n {VCC} 366.025n 0 367n 0 367.025n {VCC} 368n {VCC} 368.025n 0
+369n 0 369.025n {VCC} 370n {VCC} 370.025n 0 371n 0 371.025n {VCC} 372n {VCC} 372.025n
+0 373n 0 373.025n {VCC} 374n {VCC} 374.025n 0 375n 0 375.025n {VCC} 376n {VCC}
+376.025n 0 377n 0 377.025n {VCC} 378n {VCC} 378.025n 0 379n 0 379.025n {VCC} 380n
+{VCC} 380.025n 0 381n 0 381.025n {VCC} 382n {VCC} 382.025n 0 383n 0 383.025n {VCC}
+384n {VCC} 384.025n 0 385n 0 385.025n {VCC} 386n {VCC} 386.025n 0 387n 0 387.025n
+{VCC} 388n {VCC} 388.025n 0 389n 0 389.025n {VCC} 390n {VCC} 390.025n 0 391n 0
+391.025n {VCC} 392n {VCC} 392.025n 0 393n 0 393.025n {VCC} 394n {VCC} 394.025n 0 395n
+0 395.025n {VCC} 396n {VCC} 396.025n 0 397n 0 397.025n {VCC} 398n {VCC} 398.025n 0
+399n 0 399.025n {VCC} 400n {VCC} 400.025n 0 401n 0 401.025n {VCC} 402n {VCC} 402.025n
+0 403n 0 403.025n {VCC} 404n {VCC} 404.025n 0 405n 0 405.025n {VCC} 406n {VCC}
+406.025n 0 407n 0 407.025n {VCC} 408n {VCC} 408.025n 0 409n 0 409.025n {VCC} 410n
+{VCC} 410.025n 0 411n 0 411.025n {VCC} 412n {VCC} 412.025n 0 413n 0 413.025n {VCC}
+414n {VCC} 414.025n 0 415n 0 415.025n {VCC} 416n {VCC} 416.025n 0 417n 0 417.025n
+{VCC} 418n {VCC} 418.025n 0 419n 0 419.025n {VCC} 420n {VCC} 420.025n 0 421n 0
+421.025n {VCC} 422n {VCC} 422.025n 0 423n 0 423.025n {VCC} 424n {VCC} 424.025n 0 425n
+0 425.025n {VCC} 426n {VCC} 426.025n 0 427n 0 427.025n {VCC} 428n {VCC} 428.025n 0
+429n 0 429.025n {VCC} 430n {VCC} 430.025n 0 431n 0 431.025n {VCC} 432n {VCC} 432.025n
+0 433n 0 433.025n {VCC} 434n {VCC} 434.025n 0 435n 0 435.025n {VCC} 436n {VCC}
+436.025n 0 437n 0 437.025n {VCC} 438n {VCC} 438.025n 0 439n 0 439.025n {VCC} 440n
+{VCC} 440.025n 0 441n 0 441.025n {VCC} 442n {VCC} 442.025n 0 443n 0 443.025n {VCC}
+444n {VCC} 444.025n 0 445n 0 445.025n {VCC} 446n {VCC} 446.025n 0 447n 0 447.025n
+{VCC} 448n {VCC} 448.025n 0 449n 0 449.025n {VCC} 450n {VCC} 450.025n 0 451n 0
+451.025n {VCC} 452n {VCC} 452.025n 0 453n 0 453.025n {VCC} 454n {VCC} 454.025n 0 455n
+0 455.025n {VCC} 456n {VCC} 456.025n 0 457n 0 457.025n {VCC} 458n {VCC} 458.025n 0
+459n 0 459.025n {VCC} 460n {VCC} 460.025n 0 461n 0 461.025n {VCC} 462n {VCC} 462.025n
+0 463n 0 463.025n {VCC} 464n {VCC} 464.025n 0 465n 0 465.025n {VCC} 466n {VCC}
+466.025n 0 467n 0 467.025n {VCC} 468n {VCC} 468.025n 0 469n 0 469.025n {VCC} 470n
+{VCC} 470.025n 0 471n 0 471.025n {VCC} 472n {VCC} 472.025n 0 473n 0 473.025n {VCC}
+474n {VCC} 474.025n 0 475n 0 475.025n {VCC} 476n {VCC} 476.025n 0 477n 0 477.025n
+{VCC} 478n {VCC} 478.025n 0 479n 0 479.025n {VCC} 480n {VCC} 480.025n 0 481n 0
+481.025n {VCC} 482n {VCC} 482.025n 0 483n 0 483.025n {VCC} 484n {VCC} 484.025n 0 485n
+0 485.025n {VCC} 486n {VCC} 486.025n 0 487n 0 487.025n {VCC} 488n {VCC} 488.025n 0
+489n 0 489.025n {VCC} 490n {VCC} 490.025n 0 491n 0 491.025n {VCC} 492n {VCC} 492.025n
+0 493n 0 493.025n {VCC} 494n {VCC} 494.025n 0 495n 0 495.025n {VCC} 496n {VCC}
+496.025n 0 497n 0 497.025n {VCC} 498n {VCC} 498.025n 0 499n 0 499.025n {VCC} 500n
+{VCC} 500.025n 0 501n 0 501.025n {VCC} 502n {VCC} 502.025n 0 503n 0 503.025n {VCC}
+504n {VCC} 504.025n 0 505n 0 505.025n {VCC} 506n {VCC} 506.025n 0 507n 0 507.025n
+{VCC} 508n {VCC} 508.025n 0 509n 0 509.025n {VCC} 510n {VCC} 510.025n 0 511n 0
+511.025n {VCC} 512n {VCC} 512.025n 0 513n 0 513.025n {VCC} 514n {VCC} 514.025n 0 515n
+0 515.025n {VCC} 516n {VCC} 516.025n 0 517n 0 517.025n {VCC} 518n {VCC} 518.025n 0
+519n 0 519.025n {VCC} 520n {VCC} 520.025n 0 521n 0 521.025n {VCC} 522n {VCC} 522.025n
+0 523n 0 523.025n {VCC} 524n {VCC} 524.025n 0 525n 0 525.025n {VCC} 526n {VCC}
+526.025n 0 527n 0 527.025n {VCC} 528n {VCC} 528.025n 0 529n 0 529.025n {VCC} 530n
+{VCC} 530.025n 0 531n 0 531.025n {VCC} 532n {VCC} 532.025n 0 533n 0 533.025n {VCC}
+534n {VCC} 534.025n 0 535n 0 535.025n {VCC} 536n {VCC} 536.025n 0 537n 0 537.025n
+{VCC} 538n {VCC} 538.025n 0 539n 0 539.025n {VCC} 540n {VCC} 540.025n 0 541n 0
+541.025n {VCC} 542n {VCC} 542.025n 0 543n 0 543.025n {VCC} 544n {VCC} 544.025n 0 545n
+0 545.025n {VCC} 546n {VCC} 546.025n 0 547n 0 547.025n {VCC} 548n {VCC} 548.025n 0
+549n 0 549.025n {VCC} 550n {VCC} 550.025n 0 551n 0 551.025n {VCC} 552n {VCC} 552.025n
+0 553n 0 553.025n {VCC} 554n {VCC} 554.025n 0 555n 0 555.025n {VCC} 556n {VCC}
+556.025n 0 557n 0 557.025n {VCC} 558n {VCC} 558.025n 0 559n 0 559.025n {VCC} 560n
+{VCC} 560.025n 0 561n 0 561.025n {VCC} 562n {VCC} 562.025n 0 563n 0 563.025n {VCC}
+564n {VCC} 564.025n 0 565n 0 565.025n {VCC} 566n {VCC} 566.025n 0 567n 0 567.025n
+{VCC} 568n {VCC} 568.025n 0 569n 0 569.025n {VCC} 570n {VCC} 570.025n 0 571n 0
+571.025n {VCC} 572n {VCC} 572.025n 0 573n 0 573.025n {VCC} 574n {VCC} 574.025n 0 575n
+0 575.025n {VCC} 576n {VCC} 576.025n 0 577n 0 577.025n {VCC} 578n {VCC} 578.025n 0
+579n 0 579.025n {VCC} 580n {VCC} 580.025n 0 581n 0 581.025n {VCC} 582n {VCC} 582.025n
+0 583n 0 583.025n {VCC} 584n {VCC} 584.025n 0 585n 0 585.025n {VCC} 586n {VCC}
+586.025n 0 587n 0 587.025n {VCC} 588n {VCC} 588.025n 0 589n 0 589.025n {VCC} 590n
+{VCC} 590.025n 0 591n 0 591.025n {VCC} 592n {VCC} 592.025n 0 593n 0 593.025n {VCC}
+594n {VCC} 594.025n 0 595n 0 595.025n {VCC} 596n {VCC} 596.025n 0 597n 0 597.025n
+{VCC} 598n {VCC} 598.025n 0 599n 0 599.025n {VCC} 600n {VCC} 600.025n 0 601n 0
+601.025n {VCC} 602n {VCC} 602.025n 0 603n 0 603.025n {VCC} 604n {VCC} 604.025n 0 605n
+0 605.025n {VCC} 606n {VCC} 606.025n 0 607n 0 607.025n {VCC} 608n {VCC} 608.025n 0
+609n 0 609.025n {VCC} 610n {VCC} 610.025n 0 611n 0 611.025n {VCC} 612n {VCC} 612.025n
+0 613n 0 613.025n {VCC} 614n {VCC} 614.025n 0 615n 0 615.025n {VCC} 616n {VCC}
+616.025n 0 617n 0 617.025n {VCC} 618n {VCC} 618.025n 0 619n 0 619.025n {VCC} 620n
+{VCC} 620.025n 0 621n 0 621.025n {VCC} 622n {VCC} 622.025n 0 623n 0 623.025n {VCC}
+624n {VCC} 624.025n 0 625n 0 625.025n {VCC} 626n {VCC} 626.025n 0 627n 0 627.025n
+{VCC} 628n {VCC} 628.025n 0 629n 0 629.025n {VCC} 630n {VCC} 630.025n 0 631n 0
+631.025n {VCC} 632n {VCC} 632.025n 0 633n 0 633.025n {VCC} 634n {VCC} 634.025n 0 635n
+0 635.025n {VCC} 636n {VCC} 636.025n 0 637n 0 637.025n {VCC} 638n {VCC} 638.025n 0
+639n 0 639.025n {VCC} 640n {VCC} 640.025n 0 641n 0 641.025n {VCC} 642n {VCC} 642.025n
+0 643n 0 643.025n {VCC} 644n {VCC} 644.025n 0 645n 0 645.025n {VCC} 646n {VCC}
+646.025n 0 647n 0 647.025n {VCC} 648n {VCC} 648.025n 0 649n 0 649.025n {VCC} 650n
+{VCC} 650.025n 0 651n 0 651.025n {VCC} 652n {VCC} 652.025n 0 653n 0 653.025n {VCC}
+654n {VCC} 654.025n 0 655n 0 655.025n {VCC} 656n {VCC} 656.025n 0 657n 0 657.025n
+{VCC} 658n {VCC} 658.025n 0 659n 0 659.025n {VCC} 660n {VCC} 660.025n 0 661n 0
+661.025n {VCC} 662n {VCC} 662.025n 0 663n 0 663.025n {VCC} 664n {VCC} 664.025n 0 665n
+0 665.025n {VCC} 666n {VCC} 666.025n 0 667n 0 667.025n {VCC} 668n {VCC} 668.025n 0
+669n 0 669.025n {VCC} 670n {VCC} 670.025n 0 671n 0 671.025n {VCC} 672n {VCC} 672.025n
+0 673n 0 673.025n {VCC} 674n {VCC} 674.025n 0 675n 0 675.025n {VCC} 676n {VCC}
+676.025n 0 677n 0 677.025n {VCC} 678n {VCC} 678.025n 0 679n 0 679.025n {VCC} 680n
+{VCC} 680.025n 0 681n 0 681.025n {VCC} 682n {VCC} 682.025n 0 683n 0 683.025n {VCC}
+684n {VCC} 684.025n 0 685n 0 685.025n {VCC} 686n {VCC} 686.025n 0 687n 0 687.025n
+{VCC} 688n {VCC} 688.025n 0 689n 0 689.025n {VCC} 690n {VCC} 690.025n 0 691n 0
+691.025n {VCC} 692n {VCC} 692.025n 0 693n 0 693.025n {VCC} 694n {VCC} 694.025n 0 695n
+0 695.025n {VCC} 696n {VCC} 696.025n 0 697n 0 697.025n {VCC} 698n {VCC} 698.025n 0
+699n 0 699.025n {VCC} 700n {VCC} 700.025n 0 701n 0 701.025n {VCC} 702n {VCC} 702.025n
+0 703n 0 703.025n {VCC} 704n {VCC} 704.025n 0 705n 0 705.025n {VCC} 706n {VCC}
+706.025n 0 707n 0 707.025n {VCC} 708n {VCC} 708.025n 0 709n 0 709.025n {VCC} 710n
+{VCC} 710.025n 0 711n 0 711.025n {VCC} 712n {VCC} 712.025n 0 713n 0 713.025n {VCC}
+714n {VCC} 714.025n 0 715n 0 715.025n {VCC} 716n {VCC} 716.025n 0 717n 0 717.025n
+{VCC} 718n {VCC} 718.025n 0 719n 0 719.025n {VCC} 720n {VCC} 720.025n 0 721n 0
+721.025n {VCC} 722n {VCC} 722.025n 0 723n 0 723.025n {VCC} 724n {VCC} 724.025n 0 725n
+0 725.025n {VCC} 726n {VCC} 726.025n 0 727n 0 727.025n {VCC} 728n {VCC} 728.025n 0
+729n 0 729.025n {VCC} 730n {VCC} 730.025n 0 731n 0 731.025n {VCC} 732n {VCC} 732.025n
+0 733n 0 733.025n {VCC} 734n {VCC} 734.025n 0 735n 0 735.025n {VCC} 736n {VCC}
+736.025n 0 737n 0 737.025n {VCC} 738n {VCC} 738.025n 0 739n 0 739.025n {VCC} 740n
+{VCC} 740.025n 0 741n 0 741.025n {VCC} 742n {VCC} 742.025n 0 743n 0 743.025n {VCC}
+744n {VCC} 744.025n 0 745n 0 745.025n {VCC} 746n {VCC} 746.025n 0 747n 0 747.025n
+{VCC} 748n {VCC} 748.025n 0 749n 0 749.025n {VCC} 750n {VCC} 750.025n 0 751n 0
+751.025n {VCC} 752n {VCC} 752.025n 0 753n 0 753.025n {VCC} 754n {VCC} 754.025n 0 755n
+0 755.025n {VCC} 756n {VCC} 756.025n 0 757n 0 757.025n {VCC} 758n {VCC} 758.025n 0
+759n 0 759.025n {VCC} 760n {VCC} 760.025n 0 761n 0 761.025n {VCC} 762n {VCC} 762.025n
+0 763n 0 763.025n {VCC} 764n {VCC} 764.025n 0 765n 0 765.025n {VCC} 766n {VCC}
+766.025n 0 767n 0 767.025n {VCC} 768n {VCC} 768.025n 0 769n 0 769.025n {VCC} 770n
+{VCC} 770.025n 0 771n 0 771.025n {VCC} 772n {VCC} 772.025n 0 773n 0 773.025n {VCC}
+774n {VCC} 774.025n 0 775n 0 775.025n {VCC} 776n {VCC} 776.025n 0 777n 0 777.025n
+{VCC} 778n {VCC} 778.025n 0 779n 0 779.025n {VCC} 780n {VCC} 780.025n 0 781n 0
+781.025n {VCC} 782n {VCC} 782.025n 0 783n 0 783.025n {VCC} 784n {VCC} 784.025n 0 785n
+0 785.025n {VCC} 786n {VCC} 786.025n 0 787n 0 787.025n {VCC} 788n {VCC} 788.025n 0
+789n 0 789.025n {VCC} 790n {VCC} 790.025n 0 791n 0 791.025n {VCC} 792n {VCC} 792.025n
+0 793n 0 793.025n {VCC} 794n {VCC} 794.025n 0 795n 0 795.025n {VCC} 796n {VCC}
+796.025n 0 797n 0 797.025n {VCC} 798n {VCC} 798.025n 0 799n 0 799.025n {VCC} 800n
+{VCC} 800.025n 0 801n 0 801.025n {VCC} 802n {VCC} 802.025n 0 803n 0 803.025n {VCC}
+804n {VCC} 804.025n 0 805n 0 805.025n {VCC} 806n {VCC} 806.025n 0 807n 0 807.025n
+{VCC} 808n {VCC} 808.025n 0 809n 0 809.025n {VCC} 810n {VCC} 810.025n 0 811n 0
+811.025n {VCC} 812n {VCC} 812.025n 0 813n 0 813.025n {VCC} 814n {VCC} 814.025n 0 815n
+0 815.025n {VCC} 816n {VCC} 816.025n 0 817n 0 817.025n {VCC} 818n {VCC} 818.025n 0
+819n 0 819.025n {VCC} 820n {VCC} 820.025n 0 821n 0 821.025n {VCC} 822n {VCC} 822.025n
+0 823n 0 823.025n {VCC} 824n {VCC} 824.025n 0 825n 0 825.025n {VCC} 826n {VCC}
+826.025n 0 827n 0 827.025n {VCC} 828n {VCC} 828.025n 0 829n 0 829.025n {VCC} 830n
+{VCC} 830.025n 0 831n 0 831.025n {VCC} 832n {VCC} 832.025n 0 833n 0 833.025n {VCC}
+834n {VCC} 834.025n 0 835n 0 835.025n {VCC} 836n {VCC} 836.025n 0 837n 0 837.025n
+{VCC} 838n {VCC} 838.025n 0 839n 0 839.025n {VCC} 840n {VCC} 840.025n 0 841n 0
+841.025n {VCC} 842n {VCC} 842.025n 0 843n 0 843.025n {VCC} 844n {VCC} 844.025n 0 845n
+0 845.025n {VCC} 846n {VCC} 846.025n 0 847n 0 847.025n {VCC} 848n {VCC} 848.025n 0
+849n 0 849.025n {VCC} 850n {VCC} 850.025n 0 851n 0 851.025n {VCC} 852n {VCC} 852.025n
+0 853n 0 853.025n {VCC} 854n {VCC} 854.025n 0 855n 0 855.025n {VCC} 856n {VCC}
+856.025n 0 857n 0 857.025n {VCC} 858n {VCC} 858.025n 0 859n 0 859.025n {VCC} 860n
+{VCC} 860.025n 0 861n 0 861.025n {VCC} 862n {VCC} 862.025n 0 863n 0 863.025n {VCC}
+864n {VCC} 864.025n 0 865n 0 865.025n {VCC} 866n {VCC} 866.025n 0 867n 0 867.025n
+{VCC} 868n {VCC} 868.025n 0 869n 0 869.025n {VCC} 870n {VCC} 870.025n 0 871n 0
+871.025n {VCC} 872n {VCC} 872.025n 0 873n 0 873.025n {VCC} 874n {VCC} 874.025n 0 875n
+0 875.025n {VCC} 876n {VCC} 876.025n 0 877n 0 877.025n {VCC} 878n {VCC} 878.025n 0
+879n 0 879.025n {VCC} 880n {VCC} 880.025n 0 881n 0 881.025n {VCC} 882n {VCC} 882.025n
+0 883n 0 883.025n {VCC} 884n {VCC} 884.025n 0 885n 0 885.025n {VCC} 886n {VCC}
+886.025n 0 887n 0 887.025n {VCC} 888n {VCC} 888.025n 0 889n 0 889.025n {VCC} 890n
+{VCC} 890.025n 0 891n 0 891.025n {VCC} 892n {VCC} 892.025n 0 893n 0 893.025n {VCC}
+894n {VCC} 894.025n 0 895n 0 895.025n {VCC} 896n {VCC} 896.025n 0 897n 0 897.025n
+{VCC} 898n {VCC} 898.025n 0 899n 0 899.025n {VCC} 900n {VCC} 900.025n 0 901n 0
+901.025n {VCC} 902n {VCC} 902.025n 0 903n 0 903.025n {VCC} 904n {VCC} 904.025n 0 905n
+0 905.025n {VCC} 906n {VCC} 906.025n 0 907n 0 907.025n {VCC} 908n {VCC} 908.025n 0
+909n 0 909.025n {VCC} 910n {VCC} 910.025n 0 911n 0 911.025n {VCC} 912n {VCC} 912.025n
+0 913n 0 913.025n {VCC} 914n {VCC} 914.025n 0 915n 0 915.025n {VCC} 916n {VCC}
+916.025n 0 917n 0 917.025n {VCC} 918n {VCC} 918.025n 0 919n 0 919.025n {VCC} 920n
+{VCC} 920.025n 0 921n 0 921.025n {VCC} 922n {VCC} 922.025n 0 923n 0 923.025n {VCC}
+924n {VCC} 924.025n 0 925n 0 925.025n {VCC} 926n {VCC} 926.025n 0 927n 0 927.025n
+{VCC} 928n {VCC} 928.025n 0 929n 0 929.025n {VCC} 930n {VCC} 930.025n 0 931n 0
+931.025n {VCC} 932n {VCC} 932.025n 0 933n 0 933.025n {VCC} 934n {VCC} 934.025n 0 935n
+0 935.025n {VCC} 936n {VCC} 936.025n 0 937n 0 937.025n {VCC} 938n {VCC} 938.025n 0
+939n 0 939.025n {VCC} 940n {VCC} 940.025n 0 941n 0 941.025n {VCC} 942n {VCC} 942.025n
+0 943n 0 943.025n {VCC} 944n {VCC} 944.025n 0 945n 0 945.025n {VCC} 946n {VCC}
+946.025n 0 947n 0 947.025n {VCC} 948n {VCC} 948.025n 0 949n 0 949.025n {VCC} 950n
+{VCC} 950.025n 0 951n 0 951.025n {VCC} 952n {VCC} 952.025n 0 953n 0 953.025n {VCC}
+954n {VCC} 954.025n 0 955n 0 955.025n {VCC} 956n {VCC} 956.025n 0 957n 0 957.025n
+{VCC} 958n {VCC} 958.025n 0 959n 0 959.025n {VCC} 960n {VCC} 960.025n 0 961n 0
+961.025n {VCC} 962n {VCC} 962.025n 0 963n 0 963.025n {VCC} 964n {VCC} 964.025n 0 965n
+0 965.025n {VCC} 966n {VCC} 966.025n 0 967n 0 967.025n {VCC} 968n {VCC} 968.025n 0
+969n 0 969.025n {VCC} 970n {VCC} 970.025n 0 971n 0 971.025n {VCC} 972n {VCC} 972.025n
+0 973n 0 973.025n {VCC} 974n {VCC} 974.025n 0 975n 0 975.025n {VCC} 976n {VCC}
+976.025n 0 977n 0 977.025n {VCC} 978n {VCC} 978.025n 0 979n 0 979.025n {VCC} 980n
+{VCC} 980.025n 0 981n 0 981.025n {VCC} 982n {VCC} 982.025n 0 983n 0 983.025n {VCC}
+984n {VCC} 984.025n 0 985n 0 985.025n {VCC} 986n {VCC} 986.025n 0 987n 0 987.025n
+{VCC} 988n {VCC} 988.025n 0 989n 0 989.025n {VCC} 990n {VCC} 990.025n 0 991n 0
+991.025n {VCC} 992n {VCC} 992.025n 0 993n 0 993.025n {VCC} 994n {VCC} 994.025n 0 995n
+0 995.025n {VCC} 996n {VCC} 996.025n 0 997n 0 997.025n {VCC} 998n {VCC} 998.025n 0
+999n 0 999.025n {VCC} 1000n {VCC} 1000.025n 0 1001n 0 1001.025n {VCC} 1002n {VCC} 1002.025n
+0 1003n 0 1003.025n {VCC} 1004n {VCC} 1004.025n 0 1005n 0 1005.025n {VCC} 1006n {VCC}
+1006.025n 0 1007n 0 1007.025n {VCC} 1008n {VCC} 1008.025n 0 1009n 0 1009.025n {VCC} 1010n
+{VCC} 1010.025n 0 1011n 0 1011.025n {VCC} 1012n {VCC} 1012.025n 0 1013n 0 1013.025n {VCC}
+1014n {VCC} 1014.025n 0 1015n 0 1015.025n {VCC} 1016n {VCC} 1016.025n 0 1017n 0 1017.025n
+{VCC} 1018n {VCC} 1018.025n 0 1019n 0 1019.025n {VCC} 1020n {VCC} 1020.025n 0 1021n 0
+1021.025n {VCC} 1022n {VCC} 1022.025n 0 1023n 0 1023.025n {VCC} 1024n {VCC} 1024.025n 0 1025n
+0 1025.025n {VCC}
VA[3] A[3] 0 PWL 1n 0 3n 0 3.025n {VCC} 6n {VCC} 6.025n 0 8n
+0 8.025n {VCC} 10n {VCC} 10.025n 0 12n 0 12.025n {VCC} 14n {VCC} 14.025n 0
+16n 0 16.025n {VCC} 18n {VCC} 18.025n 0 20n 0 20.025n {VCC} 22n {VCC} 22.025n
+0 24n 0 24.025n {VCC} 26n {VCC} 26.025n 0 28n 0 28.025n {VCC} 30n {VCC}
+30.025n 0 32n 0 32.025n {VCC} 34n {VCC} 34.025n 0 36n 0 36.025n {VCC} 38n
+{VCC} 38.025n 0 40n 0 40.025n {VCC} 42n {VCC} 42.025n 0 44n 0 44.025n {VCC}
+46n {VCC} 46.025n 0 48n 0 48.025n {VCC} 50n {VCC} 50.025n 0 52n 0 52.025n
+{VCC} 54n {VCC} 54.025n 0 56n 0 56.025n {VCC} 58n {VCC} 58.025n 0 60n 0
+60.025n {VCC} 62n {VCC} 62.025n 0 64n 0 64.025n {VCC} 66n {VCC} 66.025n 0 68n
+0 68.025n {VCC} 70n {VCC} 70.025n 0 72n 0 72.025n {VCC} 74n {VCC} 74.025n 0
+76n 0 76.025n {VCC} 78n {VCC} 78.025n 0 80n 0 80.025n {VCC} 82n {VCC} 82.025n
+0 84n 0 84.025n {VCC} 86n {VCC} 86.025n 0 88n 0 88.025n {VCC} 90n {VCC}
+90.025n 0 92n 0 92.025n {VCC} 94n {VCC} 94.025n 0 96n 0 96.025n {VCC} 98n
+{VCC} 98.025n 0 100n 0 100.025n {VCC} 102n {VCC} 102.025n 0 104n 0 104.025n {VCC}
+106n {VCC} 106.025n 0 108n 0 108.025n {VCC} 110n {VCC} 110.025n 0 112n 0 112.025n
+{VCC} 114n {VCC} 114.025n 0 116n 0 116.025n {VCC} 118n {VCC} 118.025n 0 120n 0
+120.025n {VCC} 122n {VCC} 122.025n 0 124n 0 124.025n {VCC} 126n {VCC} 126.025n 0 128n
+0 128.025n {VCC} 130n {VCC} 130.025n 0 132n 0 132.025n {VCC} 134n {VCC} 134.025n 0
+136n 0 136.025n {VCC} 138n {VCC} 138.025n 0 140n 0 140.025n {VCC} 142n {VCC} 142.025n
+0 144n 0 144.025n {VCC} 146n {VCC} 146.025n 0 148n 0 148.025n {VCC} 150n {VCC}
+150.025n 0 152n 0 152.025n {VCC} 154n {VCC} 154.025n 0 156n 0 156.025n {VCC} 158n
+{VCC} 158.025n 0 160n 0 160.025n {VCC} 162n {VCC} 162.025n 0 164n 0 164.025n {VCC}
+166n {VCC} 166.025n 0 168n 0 168.025n {VCC} 170n {VCC} 170.025n 0 172n 0 172.025n
+{VCC} 174n {VCC} 174.025n 0 176n 0 176.025n {VCC} 178n {VCC} 178.025n 0 180n 0
+180.025n {VCC} 182n {VCC} 182.025n 0 184n 0 184.025n {VCC} 186n {VCC} 186.025n 0 188n
+0 188.025n {VCC} 190n {VCC} 190.025n 0 192n 0 192.025n {VCC} 194n {VCC} 194.025n 0
+196n 0 196.025n {VCC} 198n {VCC} 198.025n 0 200n 0 200.025n {VCC} 202n {VCC} 202.025n
+0 204n 0 204.025n {VCC} 206n {VCC} 206.025n 0 208n 0 208.025n {VCC} 210n {VCC}
+210.025n 0 212n 0 212.025n {VCC} 214n {VCC} 214.025n 0 216n 0 216.025n {VCC} 218n
+{VCC} 218.025n 0 220n 0 220.025n {VCC} 222n {VCC} 222.025n 0 224n 0 224.025n {VCC}
+226n {VCC} 226.025n 0 228n 0 228.025n {VCC} 230n {VCC} 230.025n 0 232n 0 232.025n
+{VCC} 234n {VCC} 234.025n 0 236n 0 236.025n {VCC} 238n {VCC} 238.025n 0 240n 0
+240.025n {VCC} 242n {VCC} 242.025n 0 244n 0 244.025n {VCC} 246n {VCC} 246.025n 0 248n
+0 248.025n {VCC} 250n {VCC} 250.025n 0 252n 0 252.025n {VCC} 254n {VCC} 254.025n 0
+256n 0 256.025n {VCC} 258n {VCC} 258.025n 0 260n 0 260.025n {VCC} 262n {VCC} 262.025n
+0 264n 0 264.025n {VCC} 266n {VCC} 266.025n 0 268n 0 268.025n {VCC} 270n {VCC}
+270.025n 0 272n 0 272.025n {VCC} 274n {VCC} 274.025n 0 276n 0 276.025n {VCC} 278n
+{VCC} 278.025n 0 280n 0 280.025n {VCC} 282n {VCC} 282.025n 0 284n 0 284.025n {VCC}
+286n {VCC} 286.025n 0 288n 0 288.025n {VCC} 290n {VCC} 290.025n 0 292n 0 292.025n
+{VCC} 294n {VCC} 294.025n 0 296n 0 296.025n {VCC} 298n {VCC} 298.025n 0 300n 0
+300.025n {VCC} 302n {VCC} 302.025n 0 304n 0 304.025n {VCC} 306n {VCC} 306.025n 0 308n
+0 308.025n {VCC} 310n {VCC} 310.025n 0 312n 0 312.025n {VCC} 314n {VCC} 314.025n 0
+316n 0 316.025n {VCC} 318n {VCC} 318.025n 0 320n 0 320.025n {VCC} 322n {VCC} 322.025n
+0 324n 0 324.025n {VCC} 326n {VCC} 326.025n 0 328n 0 328.025n {VCC} 330n {VCC}
+330.025n 0 332n 0 332.025n {VCC} 334n {VCC} 334.025n 0 336n 0 336.025n {VCC} 338n
+{VCC} 338.025n 0 340n 0 340.025n {VCC} 342n {VCC} 342.025n 0 344n 0 344.025n {VCC}
+346n {VCC} 346.025n 0 348n 0 348.025n {VCC} 350n {VCC} 350.025n 0 352n 0 352.025n
+{VCC} 354n {VCC} 354.025n 0 356n 0 356.025n {VCC} 358n {VCC} 358.025n 0 360n 0
+360.025n {VCC} 362n {VCC} 362.025n 0 364n 0 364.025n {VCC} 366n {VCC} 366.025n 0 368n
+0 368.025n {VCC} 370n {VCC} 370.025n 0 372n 0 372.025n {VCC} 374n {VCC} 374.025n 0
+376n 0 376.025n {VCC} 378n {VCC} 378.025n 0 380n 0 380.025n {VCC} 382n {VCC} 382.025n
+0 384n 0 384.025n {VCC} 386n {VCC} 386.025n 0 388n 0 388.025n {VCC} 390n {VCC}
+390.025n 0 392n 0 392.025n {VCC} 394n {VCC} 394.025n 0 396n 0 396.025n {VCC} 398n
+{VCC} 398.025n 0 400n 0 400.025n {VCC} 402n {VCC} 402.025n 0 404n 0 404.025n {VCC}
+406n {VCC} 406.025n 0 408n 0 408.025n {VCC} 410n {VCC} 410.025n 0 412n 0 412.025n
+{VCC} 414n {VCC} 414.025n 0 416n 0 416.025n {VCC} 418n {VCC} 418.025n 0 420n 0
+420.025n {VCC} 422n {VCC} 422.025n 0 424n 0 424.025n {VCC} 426n {VCC} 426.025n 0 428n
+0 428.025n {VCC} 430n {VCC} 430.025n 0 432n 0 432.025n {VCC} 434n {VCC} 434.025n 0
+436n 0 436.025n {VCC} 438n {VCC} 438.025n 0 440n 0 440.025n {VCC} 442n {VCC} 442.025n
+0 444n 0 444.025n {VCC} 446n {VCC} 446.025n 0 448n 0 448.025n {VCC} 450n {VCC}
+450.025n 0 452n 0 452.025n {VCC} 454n {VCC} 454.025n 0 456n 0 456.025n {VCC} 458n
+{VCC} 458.025n 0 460n 0 460.025n {VCC} 462n {VCC} 462.025n 0 464n 0 464.025n {VCC}
+466n {VCC} 466.025n 0 468n 0 468.025n {VCC} 470n {VCC} 470.025n 0 472n 0 472.025n
+{VCC} 474n {VCC} 474.025n 0 476n 0 476.025n {VCC} 478n {VCC} 478.025n 0 480n 0
+480.025n {VCC} 482n {VCC} 482.025n 0 484n 0 484.025n {VCC} 486n {VCC} 486.025n 0 488n
+0 488.025n {VCC} 490n {VCC} 490.025n 0 492n 0 492.025n {VCC} 494n {VCC} 494.025n 0
+496n 0 496.025n {VCC} 498n {VCC} 498.025n 0 500n 0 500.025n {VCC} 502n {VCC} 502.025n
+0 504n 0 504.025n {VCC} 506n {VCC} 506.025n 0 508n 0 508.025n {VCC} 510n {VCC}
+510.025n 0 512n 0 512.025n {VCC} 514n {VCC} 514.025n 0 516n 0 516.025n {VCC} 518n
+{VCC} 518.025n 0 520n 0 520.025n {VCC} 522n {VCC} 522.025n 0 524n 0 524.025n {VCC}
+526n {VCC} 526.025n 0 528n 0 528.025n {VCC} 530n {VCC} 530.025n 0 532n 0 532.025n
+{VCC} 534n {VCC} 534.025n 0 536n 0 536.025n {VCC} 538n {VCC} 538.025n 0 540n 0
+540.025n {VCC} 542n {VCC} 542.025n 0 544n 0 544.025n {VCC} 546n {VCC} 546.025n 0 548n
+0 548.025n {VCC} 550n {VCC} 550.025n 0 552n 0 552.025n {VCC} 554n {VCC} 554.025n 0
+556n 0 556.025n {VCC} 558n {VCC} 558.025n 0 560n 0 560.025n {VCC} 562n {VCC} 562.025n
+0 564n 0 564.025n {VCC} 566n {VCC} 566.025n 0 568n 0 568.025n {VCC} 570n {VCC}
+570.025n 0 572n 0 572.025n {VCC} 574n {VCC} 574.025n 0 576n 0 576.025n {VCC} 578n
+{VCC} 578.025n 0 580n 0 580.025n {VCC} 582n {VCC} 582.025n 0 584n 0 584.025n {VCC}
+586n {VCC} 586.025n 0 588n 0 588.025n {VCC} 590n {VCC} 590.025n 0 592n 0 592.025n
+{VCC} 594n {VCC} 594.025n 0 596n 0 596.025n {VCC} 598n {VCC} 598.025n 0 600n 0
+600.025n {VCC} 602n {VCC} 602.025n 0 604n 0 604.025n {VCC} 606n {VCC} 606.025n 0 608n
+0 608.025n {VCC} 610n {VCC} 610.025n 0 612n 0 612.025n {VCC} 614n {VCC} 614.025n 0
+616n 0 616.025n {VCC} 618n {VCC} 618.025n 0 620n 0 620.025n {VCC} 622n {VCC} 622.025n
+0 624n 0 624.025n {VCC} 626n {VCC} 626.025n 0 628n 0 628.025n {VCC} 630n {VCC}
+630.025n 0 632n 0 632.025n {VCC} 634n {VCC} 634.025n 0 636n 0 636.025n {VCC} 638n
+{VCC} 638.025n 0 640n 0 640.025n {VCC} 642n {VCC} 642.025n 0 644n 0 644.025n {VCC}
+646n {VCC} 646.025n 0 648n 0 648.025n {VCC} 650n {VCC} 650.025n 0 652n 0 652.025n
+{VCC} 654n {VCC} 654.025n 0 656n 0 656.025n {VCC} 658n {VCC} 658.025n 0 660n 0
+660.025n {VCC} 662n {VCC} 662.025n 0 664n 0 664.025n {VCC} 666n {VCC} 666.025n 0 668n
+0 668.025n {VCC} 670n {VCC} 670.025n 0 672n 0 672.025n {VCC} 674n {VCC} 674.025n 0
+676n 0 676.025n {VCC} 678n {VCC} 678.025n 0 680n 0 680.025n {VCC} 682n {VCC} 682.025n
+0 684n 0 684.025n {VCC} 686n {VCC} 686.025n 0 688n 0 688.025n {VCC} 690n {VCC}
+690.025n 0 692n 0 692.025n {VCC} 694n {VCC} 694.025n 0 696n 0 696.025n {VCC} 698n
+{VCC} 698.025n 0 700n 0 700.025n {VCC} 702n {VCC} 702.025n 0 704n 0 704.025n {VCC}
+706n {VCC} 706.025n 0 708n 0 708.025n {VCC} 710n {VCC} 710.025n 0 712n 0 712.025n
+{VCC} 714n {VCC} 714.025n 0 716n 0 716.025n {VCC} 718n {VCC} 718.025n 0 720n 0
+720.025n {VCC} 722n {VCC} 722.025n 0 724n 0 724.025n {VCC} 726n {VCC} 726.025n 0 728n
+0 728.025n {VCC} 730n {VCC} 730.025n 0 732n 0 732.025n {VCC} 734n {VCC} 734.025n 0
+736n 0 736.025n {VCC} 738n {VCC} 738.025n 0 740n 0 740.025n {VCC} 742n {VCC} 742.025n
+0 744n 0 744.025n {VCC} 746n {VCC} 746.025n 0 748n 0 748.025n {VCC} 750n {VCC}
+750.025n 0 752n 0 752.025n {VCC} 754n {VCC} 754.025n 0 756n 0 756.025n {VCC} 758n
+{VCC} 758.025n 0 760n 0 760.025n {VCC} 762n {VCC} 762.025n 0 764n 0 764.025n {VCC}
+766n {VCC} 766.025n 0 768n 0 768.025n {VCC} 770n {VCC} 770.025n 0 772n 0 772.025n
+{VCC} 774n {VCC} 774.025n 0 776n 0 776.025n {VCC} 778n {VCC} 778.025n 0 780n 0
+780.025n {VCC} 782n {VCC} 782.025n 0 784n 0 784.025n {VCC} 786n {VCC} 786.025n 0 788n
+0 788.025n {VCC} 790n {VCC} 790.025n 0 792n 0 792.025n {VCC} 794n {VCC} 794.025n 0
+796n 0 796.025n {VCC} 798n {VCC} 798.025n 0 800n 0 800.025n {VCC} 802n {VCC} 802.025n
+0 804n 0 804.025n {VCC} 806n {VCC} 806.025n 0 808n 0 808.025n {VCC} 810n {VCC}
+810.025n 0 812n 0 812.025n {VCC} 814n {VCC} 814.025n 0 816n 0 816.025n {VCC} 818n
+{VCC} 818.025n 0 820n 0 820.025n {VCC} 822n {VCC} 822.025n 0 824n 0 824.025n {VCC}
+826n {VCC} 826.025n 0 828n 0 828.025n {VCC} 830n {VCC} 830.025n 0 832n 0 832.025n
+{VCC} 834n {VCC} 834.025n 0 836n 0 836.025n {VCC} 838n {VCC} 838.025n 0 840n 0
+840.025n {VCC} 842n {VCC} 842.025n 0 844n 0 844.025n {VCC} 846n {VCC} 846.025n 0 848n
+0 848.025n {VCC} 850n {VCC} 850.025n 0 852n 0 852.025n {VCC} 854n {VCC} 854.025n 0
+856n 0 856.025n {VCC} 858n {VCC} 858.025n 0 860n 0 860.025n {VCC} 862n {VCC} 862.025n
+0 864n 0 864.025n {VCC} 866n {VCC} 866.025n 0 868n 0 868.025n {VCC} 870n {VCC}
+870.025n 0 872n 0 872.025n {VCC} 874n {VCC} 874.025n 0 876n 0 876.025n {VCC} 878n
+{VCC} 878.025n 0 880n 0 880.025n {VCC} 882n {VCC} 882.025n 0 884n 0 884.025n {VCC}
+886n {VCC} 886.025n 0 888n 0 888.025n {VCC} 890n {VCC} 890.025n 0 892n 0 892.025n
+{VCC} 894n {VCC} 894.025n 0 896n 0 896.025n {VCC} 898n {VCC} 898.025n 0 900n 0
+900.025n {VCC} 902n {VCC} 902.025n 0 904n 0 904.025n {VCC} 906n {VCC} 906.025n 0 908n
+0 908.025n {VCC} 910n {VCC} 910.025n 0 912n 0 912.025n {VCC} 914n {VCC} 914.025n 0
+916n 0 916.025n {VCC} 918n {VCC} 918.025n 0 920n 0 920.025n {VCC} 922n {VCC} 922.025n
+0 924n 0 924.025n {VCC} 926n {VCC} 926.025n 0 928n 0 928.025n {VCC} 930n {VCC}
+930.025n 0 932n 0 932.025n {VCC} 934n {VCC} 934.025n 0 936n 0 936.025n {VCC} 938n
+{VCC} 938.025n 0 940n 0 940.025n {VCC} 942n {VCC} 942.025n 0 944n 0 944.025n {VCC}
+946n {VCC} 946.025n 0 948n 0 948.025n {VCC} 950n {VCC} 950.025n 0 952n 0 952.025n
+{VCC} 954n {VCC} 954.025n 0 956n 0 956.025n {VCC} 958n {VCC} 958.025n 0 960n 0
+960.025n {VCC} 962n {VCC} 962.025n 0 964n 0 964.025n {VCC} 966n {VCC} 966.025n 0 968n
+0 968.025n {VCC} 970n {VCC} 970.025n 0 972n 0 972.025n {VCC} 974n {VCC} 974.025n 0
+976n 0 976.025n {VCC} 978n {VCC} 978.025n 0 980n 0 980.025n {VCC} 982n {VCC} 982.025n
+0 984n 0 984.025n {VCC} 986n {VCC} 986.025n 0 988n 0 988.025n {VCC} 990n {VCC}
+990.025n 0 992n 0 992.025n {VCC} 994n {VCC} 994.025n 0 996n 0 996.025n {VCC} 998n
+{VCC} 998.025n 0 1000n 0 1000.025n {VCC} 1002n {VCC} 1002.025n 0 1004n 0 1004.025n {VCC}
+1006n {VCC} 1006.025n 0 1008n 0 1008.025n {VCC} 1010n {VCC} 1010.025n 0 1012n 0 1012.025n
+{VCC} 1014n {VCC} 1014.025n 0 1016n 0 1016.025n {VCC} 1018n {VCC} 1018.025n 0 1020n 0
+1020.025n {VCC} 1022n {VCC} 1022.025n 0 1024n 0 1024.025n {VCC}
VA[4] A[4] 0 PWL 1n 0 5n 0 5.025n {VCC} 10n {VCC} 10.025n 0 14n
+0 14.025n {VCC} 18n {VCC} 18.025n 0 22n 0 22.025n {VCC} 26n {VCC} 26.025n 0
+30n 0 30.025n {VCC} 34n {VCC} 34.025n 0 38n 0 38.025n {VCC} 42n {VCC} 42.025n
+0 46n 0 46.025n {VCC} 50n {VCC} 50.025n 0 54n 0 54.025n {VCC} 58n {VCC}
+58.025n 0 62n 0 62.025n {VCC} 66n {VCC} 66.025n 0 70n 0 70.025n {VCC} 74n
+{VCC} 74.025n 0 78n 0 78.025n {VCC} 82n {VCC} 82.025n 0 86n 0 86.025n {VCC}
+90n {VCC} 90.025n 0 94n 0 94.025n {VCC} 98n {VCC} 98.025n 0 102n 0 102.025n
+{VCC} 106n {VCC} 106.025n 0 110n 0 110.025n {VCC} 114n {VCC} 114.025n 0 118n 0
+118.025n {VCC} 122n {VCC} 122.025n 0 126n 0 126.025n {VCC} 130n {VCC} 130.025n 0 134n
+0 134.025n {VCC} 138n {VCC} 138.025n 0 142n 0 142.025n {VCC} 146n {VCC} 146.025n 0
+150n 0 150.025n {VCC} 154n {VCC} 154.025n 0 158n 0 158.025n {VCC} 162n {VCC} 162.025n
+0 166n 0 166.025n {VCC} 170n {VCC} 170.025n 0 174n 0 174.025n {VCC} 178n {VCC}
+178.025n 0 182n 0 182.025n {VCC} 186n {VCC} 186.025n 0 190n 0 190.025n {VCC} 194n
+{VCC} 194.025n 0 198n 0 198.025n {VCC} 202n {VCC} 202.025n 0 206n 0 206.025n {VCC}
+210n {VCC} 210.025n 0 214n 0 214.025n {VCC} 218n {VCC} 218.025n 0 222n 0 222.025n
+{VCC} 226n {VCC} 226.025n 0 230n 0 230.025n {VCC} 234n {VCC} 234.025n 0 238n 0
+238.025n {VCC} 242n {VCC} 242.025n 0 246n 0 246.025n {VCC} 250n {VCC} 250.025n 0 254n
+0 254.025n {VCC} 258n {VCC} 258.025n 0 262n 0 262.025n {VCC} 266n {VCC} 266.025n 0
+270n 0 270.025n {VCC} 274n {VCC} 274.025n 0 278n 0 278.025n {VCC} 282n {VCC} 282.025n
+0 286n 0 286.025n {VCC} 290n {VCC} 290.025n 0 294n 0 294.025n {VCC} 298n {VCC}
+298.025n 0 302n 0 302.025n {VCC} 306n {VCC} 306.025n 0 310n 0 310.025n {VCC} 314n
+{VCC} 314.025n 0 318n 0 318.025n {VCC} 322n {VCC} 322.025n 0 326n 0 326.025n {VCC}
+330n {VCC} 330.025n 0 334n 0 334.025n {VCC} 338n {VCC} 338.025n 0 342n 0 342.025n
+{VCC} 346n {VCC} 346.025n 0 350n 0 350.025n {VCC} 354n {VCC} 354.025n 0 358n 0
+358.025n {VCC} 362n {VCC} 362.025n 0 366n 0 366.025n {VCC} 370n {VCC} 370.025n 0 374n
+0 374.025n {VCC} 378n {VCC} 378.025n 0 382n 0 382.025n {VCC} 386n {VCC} 386.025n 0
+390n 0 390.025n {VCC} 394n {VCC} 394.025n 0 398n 0 398.025n {VCC} 402n {VCC} 402.025n
+0 406n 0 406.025n {VCC} 410n {VCC} 410.025n 0 414n 0 414.025n {VCC} 418n {VCC}
+418.025n 0 422n 0 422.025n {VCC} 426n {VCC} 426.025n 0 430n 0 430.025n {VCC} 434n
+{VCC} 434.025n 0 438n 0 438.025n {VCC} 442n {VCC} 442.025n 0 446n 0 446.025n {VCC}
+450n {VCC} 450.025n 0 454n 0 454.025n {VCC} 458n {VCC} 458.025n 0 462n 0 462.025n
+{VCC} 466n {VCC} 466.025n 0 470n 0 470.025n {VCC} 474n {VCC} 474.025n 0 478n 0
+478.025n {VCC} 482n {VCC} 482.025n 0 486n 0 486.025n {VCC} 490n {VCC} 490.025n 0 494n
+0 494.025n {VCC} 498n {VCC} 498.025n 0 502n 0 502.025n {VCC} 506n {VCC} 506.025n 0
+510n 0 510.025n {VCC} 514n {VCC} 514.025n 0 518n 0 518.025n {VCC} 522n {VCC} 522.025n
+0 526n 0 526.025n {VCC} 530n {VCC} 530.025n 0 534n 0 534.025n {VCC} 538n {VCC}
+538.025n 0 542n 0 542.025n {VCC} 546n {VCC} 546.025n 0 550n 0 550.025n {VCC} 554n
+{VCC} 554.025n 0 558n 0 558.025n {VCC} 562n {VCC} 562.025n 0 566n 0 566.025n {VCC}
+570n {VCC} 570.025n 0 574n 0 574.025n {VCC} 578n {VCC} 578.025n 0 582n 0 582.025n
+{VCC} 586n {VCC} 586.025n 0 590n 0 590.025n {VCC} 594n {VCC} 594.025n 0 598n 0
+598.025n {VCC} 602n {VCC} 602.025n 0 606n 0 606.025n {VCC} 610n {VCC} 610.025n 0 614n
+0 614.025n {VCC} 618n {VCC} 618.025n 0 622n 0 622.025n {VCC} 626n {VCC} 626.025n 0
+630n 0 630.025n {VCC} 634n {VCC} 634.025n 0 638n 0 638.025n {VCC} 642n {VCC} 642.025n
+0 646n 0 646.025n {VCC} 650n {VCC} 650.025n 0 654n 0 654.025n {VCC} 658n {VCC}
+658.025n 0 662n 0 662.025n {VCC} 666n {VCC} 666.025n 0 670n 0 670.025n {VCC} 674n
+{VCC} 674.025n 0 678n 0 678.025n {VCC} 682n {VCC} 682.025n 0 686n 0 686.025n {VCC}
+690n {VCC} 690.025n 0 694n 0 694.025n {VCC} 698n {VCC} 698.025n 0 702n 0 702.025n
+{VCC} 706n {VCC} 706.025n 0 710n 0 710.025n {VCC} 714n {VCC} 714.025n 0 718n 0
+718.025n {VCC} 722n {VCC} 722.025n 0 726n 0 726.025n {VCC} 730n {VCC} 730.025n 0 734n
+0 734.025n {VCC} 738n {VCC} 738.025n 0 742n 0 742.025n {VCC} 746n {VCC} 746.025n 0
+750n 0 750.025n {VCC} 754n {VCC} 754.025n 0 758n 0 758.025n {VCC} 762n {VCC} 762.025n
+0 766n 0 766.025n {VCC} 770n {VCC} 770.025n 0 774n 0 774.025n {VCC} 778n {VCC}
+778.025n 0 782n 0 782.025n {VCC} 786n {VCC} 786.025n 0 790n 0 790.025n {VCC} 794n
+{VCC} 794.025n 0 798n 0 798.025n {VCC} 802n {VCC} 802.025n 0 806n 0 806.025n {VCC}
+810n {VCC} 810.025n 0 814n 0 814.025n {VCC} 818n {VCC} 818.025n 0 822n 0 822.025n
+{VCC} 826n {VCC} 826.025n 0 830n 0 830.025n {VCC} 834n {VCC} 834.025n 0 838n 0
+838.025n {VCC} 842n {VCC} 842.025n 0 846n 0 846.025n {VCC} 850n {VCC} 850.025n 0 854n
+0 854.025n {VCC} 858n {VCC} 858.025n 0 862n 0 862.025n {VCC} 866n {VCC} 866.025n 0
+870n 0 870.025n {VCC} 874n {VCC} 874.025n 0 878n 0 878.025n {VCC} 882n {VCC} 882.025n
+0 886n 0 886.025n {VCC} 890n {VCC} 890.025n 0 894n 0 894.025n {VCC} 898n {VCC}
+898.025n 0 902n 0 902.025n {VCC} 906n {VCC} 906.025n 0 910n 0 910.025n {VCC} 914n
+{VCC} 914.025n 0 918n 0 918.025n {VCC} 922n {VCC} 922.025n 0 926n 0 926.025n {VCC}
+930n {VCC} 930.025n 0 934n 0 934.025n {VCC} 938n {VCC} 938.025n 0 942n 0 942.025n
+{VCC} 946n {VCC} 946.025n 0 950n 0 950.025n {VCC} 954n {VCC} 954.025n 0 958n 0
+958.025n {VCC} 962n {VCC} 962.025n 0 966n 0 966.025n {VCC} 970n {VCC} 970.025n 0 974n
+0 974.025n {VCC} 978n {VCC} 978.025n 0 982n 0 982.025n {VCC} 986n {VCC} 986.025n 0
+990n 0 990.025n {VCC} 994n {VCC} 994.025n 0 998n 0 998.025n {VCC} 1002n {VCC} 1002.025n
+0 1006n 0 1006.025n {VCC} 1010n {VCC} 1010.025n 0 1014n 0 1014.025n {VCC} 1018n {VCC}
+1018.025n 0 1022n 0 1022.025n {VCC}
VA[5] A[5] 0 PWL 1n 0 5n 0 5.025n {VCC} 6n {VCC} 6.025n 0 10n
+0 10.025n {VCC} 18n {VCC} 18.025n 0 26n 0 26.025n {VCC} 34n {VCC} 34.025n 0
+42n 0 42.025n {VCC} 50n {VCC} 50.025n 0 58n 0 58.025n {VCC} 66n {VCC} 66.025n
+0 74n 0 74.025n {VCC} 82n {VCC} 82.025n 0 90n 0 90.025n {VCC} 98n {VCC}
+98.025n 0 106n 0 106.025n {VCC} 114n {VCC} 114.025n 0 122n 0 122.025n {VCC} 130n
+{VCC} 130.025n 0 138n 0 138.025n {VCC} 146n {VCC} 146.025n 0 154n 0 154.025n {VCC}
+162n {VCC} 162.025n 0 170n 0 170.025n {VCC} 178n {VCC} 178.025n 0 186n 0 186.025n
+{VCC} 194n {VCC} 194.025n 0 202n 0 202.025n {VCC} 210n {VCC} 210.025n 0 218n 0
+218.025n {VCC} 226n {VCC} 226.025n 0 234n 0 234.025n {VCC} 242n {VCC} 242.025n 0 250n
+0 250.025n {VCC} 258n {VCC} 258.025n 0 266n 0 266.025n {VCC} 274n {VCC} 274.025n 0
+282n 0 282.025n {VCC} 290n {VCC} 290.025n 0 298n 0 298.025n {VCC} 306n {VCC} 306.025n
+0 314n 0 314.025n {VCC} 322n {VCC} 322.025n 0 330n 0 330.025n {VCC} 338n {VCC}
+338.025n 0 346n 0 346.025n {VCC} 354n {VCC} 354.025n 0 362n 0 362.025n {VCC} 370n
+{VCC} 370.025n 0 378n 0 378.025n {VCC} 386n {VCC} 386.025n 0 394n 0 394.025n {VCC}
+402n {VCC} 402.025n 0 410n 0 410.025n {VCC} 418n {VCC} 418.025n 0 426n 0 426.025n
+{VCC} 434n {VCC} 434.025n 0 442n 0 442.025n {VCC} 450n {VCC} 450.025n 0 458n 0
+458.025n {VCC} 466n {VCC} 466.025n 0 474n 0 474.025n {VCC} 482n {VCC} 482.025n 0 490n
+0 490.025n {VCC} 498n {VCC} 498.025n 0 506n 0 506.025n {VCC} 514n {VCC} 514.025n 0
+522n 0 522.025n {VCC} 530n {VCC} 530.025n 0 538n 0 538.025n {VCC} 546n {VCC} 546.025n
+0 554n 0 554.025n {VCC} 562n {VCC} 562.025n 0 570n 0 570.025n {VCC} 578n {VCC}
+578.025n 0 586n 0 586.025n {VCC} 594n {VCC} 594.025n 0 602n 0 602.025n {VCC} 610n
+{VCC} 610.025n 0 618n 0 618.025n {VCC} 626n {VCC} 626.025n 0 634n 0 634.025n {VCC}
+642n {VCC} 642.025n 0 650n 0 650.025n {VCC} 658n {VCC} 658.025n 0 666n 0 666.025n
+{VCC} 674n {VCC} 674.025n 0 682n 0 682.025n {VCC} 690n {VCC} 690.025n 0 698n 0
+698.025n {VCC} 706n {VCC} 706.025n 0 714n 0 714.025n {VCC} 722n {VCC} 722.025n 0 730n
+0 730.025n {VCC} 738n {VCC} 738.025n 0 746n 0 746.025n {VCC} 754n {VCC} 754.025n 0
+762n 0 762.025n {VCC} 770n {VCC} 770.025n 0 778n 0 778.025n {VCC} 786n {VCC} 786.025n
+0 794n 0 794.025n {VCC} 802n {VCC} 802.025n 0 810n 0 810.025n {VCC} 818n {VCC}
+818.025n 0 826n 0 826.025n {VCC} 834n {VCC} 834.025n 0 842n 0 842.025n {VCC} 850n
+{VCC} 850.025n 0 858n 0 858.025n {VCC} 866n {VCC} 866.025n 0 874n 0 874.025n {VCC}
+882n {VCC} 882.025n 0 890n 0 890.025n {VCC} 898n {VCC} 898.025n 0 906n 0 906.025n
+{VCC} 914n {VCC} 914.025n 0 922n 0 922.025n {VCC} 930n {VCC} 930.025n 0 938n 0
+938.025n {VCC} 946n {VCC} 946.025n 0 954n 0 954.025n {VCC} 962n {VCC} 962.025n 0 970n
+0 970.025n {VCC} 978n {VCC} 978.025n 0 986n 0 986.025n {VCC} 994n {VCC} 994.025n 0
+1002n 0 1002.025n {VCC} 1010n {VCC} 1010.025n 0 1018n 0 1018.025n {VCC}
VA[6] A[6] 0 PWL 1n 0 5n 0 5.025n {VCC} 6n {VCC} 6.025n 0 18n
+0 18.025n {VCC} 34n {VCC} 34.025n 0 50n 0 50.025n {VCC} 66n {VCC} 66.025n 0
+82n 0 82.025n {VCC} 98n {VCC} 98.025n 0 114n 0 114.025n {VCC} 130n {VCC} 130.025n
+0 146n 0 146.025n {VCC} 162n {VCC} 162.025n 0 178n 0 178.025n {VCC} 194n {VCC}
+194.025n 0 210n 0 210.025n {VCC} 226n {VCC} 226.025n 0 242n 0 242.025n {VCC} 258n
+{VCC} 258.025n 0 274n 0 274.025n {VCC} 290n {VCC} 290.025n 0 306n 0 306.025n {VCC}
+322n {VCC} 322.025n 0 338n 0 338.025n {VCC} 354n {VCC} 354.025n 0 370n 0 370.025n
+{VCC} 386n {VCC} 386.025n 0 402n 0 402.025n {VCC} 418n {VCC} 418.025n 0 434n 0
+434.025n {VCC} 450n {VCC} 450.025n 0 466n 0 466.025n {VCC} 482n {VCC} 482.025n 0 498n
+0 498.025n {VCC} 514n {VCC} 514.025n 0 530n 0 530.025n {VCC} 546n {VCC} 546.025n 0
+562n 0 562.025n {VCC} 578n {VCC} 578.025n 0 594n 0 594.025n {VCC} 610n {VCC} 610.025n
+0 626n 0 626.025n {VCC} 642n {VCC} 642.025n 0 658n 0 658.025n {VCC} 674n {VCC}
+674.025n 0 690n 0 690.025n {VCC} 706n {VCC} 706.025n 0 722n 0 722.025n {VCC} 738n
+{VCC} 738.025n 0 754n 0 754.025n {VCC} 770n {VCC} 770.025n 0 786n 0 786.025n {VCC}
+802n {VCC} 802.025n 0 818n 0 818.025n {VCC} 834n {VCC} 834.025n 0 850n 0 850.025n
+{VCC} 866n {VCC} 866.025n 0 882n 0 882.025n {VCC} 898n {VCC} 898.025n 0 914n 0
+914.025n {VCC} 930n {VCC} 930.025n 0 946n 0 946.025n {VCC} 962n {VCC} 962.025n 0 978n
+0 978.025n {VCC} 994n {VCC} 994.025n 0 1010n 0 1010.025n {VCC}
VA[7] A[7] 0 PWL 1n 0 5n 0 5.025n {VCC} 6n {VCC} 6.025n 0 34n
+0 34.025n {VCC} 66n {VCC} 66.025n 0 98n 0 98.025n {VCC} 130n {VCC} 130.025n 0
+162n 0 162.025n {VCC} 194n {VCC} 194.025n 0 226n 0 226.025n {VCC} 258n {VCC} 258.025n
+0 290n 0 290.025n {VCC} 322n {VCC} 322.025n 0 354n 0 354.025n {VCC} 386n {VCC}
+386.025n 0 418n 0 418.025n {VCC} 450n {VCC} 450.025n 0 482n 0 482.025n {VCC} 514n
+{VCC} 514.025n 0 546n 0 546.025n {VCC} 578n {VCC} 578.025n 0 610n 0 610.025n {VCC}
+642n {VCC} 642.025n 0 674n 0 674.025n {VCC} 706n {VCC} 706.025n 0 738n 0 738.025n
+{VCC} 770n {VCC} 770.025n 0 802n 0 802.025n {VCC} 834n {VCC} 834.025n 0 866n 0
+866.025n {VCC} 898n {VCC} 898.025n 0 930n 0 930.025n {VCC} 962n {VCC} 962.025n 0 994n
+0 994.025n {VCC}
VA[8] A[8] 0 PWL 1n 0 5n 0 5.025n {VCC} 6n {VCC} 6.025n 0 66n
+0 66.025n {VCC} 130n {VCC} 130.025n 0 194n 0 194.025n {VCC} 258n {VCC} 258.025n 0
+322n 0 322.025n {VCC} 386n {VCC} 386.025n 0 450n 0 450.025n {VCC} 514n {VCC} 514.025n
+0 578n 0 578.025n {VCC} 642n {VCC} 642.025n 0 706n 0 706.025n {VCC} 770n {VCC}
+770.025n 0 834n 0 834.025n {VCC} 898n {VCC} 898.025n 0 962n 0 962.025n {VCC}
VA[10] A[10] 0 PWL 1n 0 5n 0 5.025n {VCC} 6n {VCC} 6.025n 0 258n
+0 258.025n {VCC} 514n {VCC} 514.025n 0 770n 0 770.025n {VCC}
VA[9] A[9] 0 PWL 1n 0 5n 0 5.025n {VCC} 6n {VCC} 6.025n 0 130n
+0 130.025n {VCC} 258n {VCC} 258.025n 0 386n 0 386.025n {VCC} 514n {VCC} 514.025n 0
+642n 0 642.025n {VCC} 770n {VCC} 770.025n 0 898n 0 898.025n {VCC}
VA[11] A[11] 0 PWL 1n 0 5n 0 5.025n {VCC} 6n {VCC} 6.025n 0 514n
+0 514.025n {VCC}
