**************************************
* SPICE STIMULI FILE
* generated from
**************************************

VA[0] A[0] 0 PWL 1n 0
VA[1] A[1] 0 PWL 1n 0
VA[2] A[2] 0 PWL 1n 0 2n 0 2.1n {VCC} 3n {VCC} 3.1n 0 4n
+0 4.1n {VCC} 5n {VCC} 5.1n 0 6n 0 6.1n {VCC} 7n {VCC} 7.1n 0
+8n 0 8.1n {VCC} 9n {VCC} 9.1n 0 10n 0 10.1n {VCC} 11n {VCC} 11.1n
+0 12n 0 12.1n {VCC} 13n {VCC} 13.1n 0 14n 0 14.1n {VCC} 15n {VCC}
+15.1n 0 16n 0 16.1n {VCC} 17n {VCC} 17.1n 0 18n 0 18.1n {VCC} 19n
+{VCC} 19.1n 0 20n 0 20.1n {VCC} 21n {VCC} 21.1n 0 22n 0 22.1n {VCC}
+23n {VCC} 23.1n 0 24n 0 24.1n {VCC} 25n {VCC} 25.1n 0 26n 0 26.1n
+{VCC} 27n {VCC} 27.1n 0 28n 0 28.1n {VCC} 29n {VCC} 29.1n 0 30n 0
+30.1n {VCC} 31n {VCC} 31.1n 0 32n 0 32.1n {VCC} 33n {VCC} 33.1n 0 34n
+0 34.1n {VCC} 35n {VCC} 35.1n 0 36n 0 36.1n {VCC} 37n {VCC} 37.1n 0
+38n 0 38.1n {VCC} 39n {VCC} 39.1n 0 40n 0 40.1n {VCC} 41n {VCC} 41.1n
+0 42n 0 42.1n {VCC} 43n {VCC} 43.1n 0 44n 0 44.1n {VCC} 45n {VCC}
+45.1n 0 46n 0 46.1n {VCC} 47n {VCC} 47.1n 0 48n 0 48.1n {VCC} 49n
+{VCC} 49.1n 0 50n 0 50.1n {VCC} 51n {VCC} 51.1n 0 52n 0 52.1n {VCC}
+53n {VCC} 53.1n 0 54n 0 54.1n {VCC} 55n {VCC} 55.1n 0 56n 0 56.1n
+{VCC} 57n {VCC} 57.1n 0 58n 0 58.1n {VCC} 59n {VCC} 59.1n 0 60n 0
+60.1n {VCC} 61n {VCC} 61.1n 0 62n 0 62.1n {VCC} 63n {VCC} 63.1n 0 64n
+0 64.1n {VCC} 65n {VCC} 65.1n 0 66n 0 66.1n {VCC} 67n {VCC} 67.1n 0
+68n 0 68.1n {VCC} 69n {VCC} 69.1n 0 70n 0 70.1n {VCC} 71n {VCC} 71.1n
+0 72n 0 72.1n {VCC} 73n {VCC} 73.1n 0 74n 0 74.1n {VCC} 75n {VCC}
+75.1n 0 76n 0 76.1n {VCC} 77n {VCC} 77.1n 0 78n 0 78.1n {VCC} 79n
+{VCC} 79.1n 0 80n 0 80.1n {VCC} 81n {VCC} 81.1n 0 82n 0 82.1n {VCC}
+83n {VCC} 83.1n 0 84n 0 84.1n {VCC} 85n {VCC} 85.1n 0 86n 0 86.1n
+{VCC} 87n {VCC} 87.1n 0 88n 0 88.1n {VCC} 89n {VCC} 89.1n 0 90n 0
+90.1n {VCC} 91n {VCC} 91.1n 0 92n 0 92.1n {VCC} 93n {VCC} 93.1n 0 94n
+0 94.1n {VCC} 95n {VCC} 95.1n 0 96n 0 96.1n {VCC} 97n {VCC} 97.1n 0
+98n 0 98.1n {VCC} 99n {VCC} 99.1n 0 100n 0 100.1n {VCC} 101n {VCC} 101.1n
+0 102n 0 102.1n {VCC} 103n {VCC} 103.1n 0 104n 0 104.1n {VCC} 105n {VCC}
+105.1n 0 106n 0 106.1n {VCC} 107n {VCC} 107.1n 0 108n 0 108.1n {VCC} 109n
+{VCC} 109.1n 0 110n 0 110.1n {VCC} 111n {VCC} 111.1n 0 112n 0 112.1n {VCC}
+113n {VCC} 113.1n 0 114n 0 114.1n {VCC} 115n {VCC} 115.1n 0 116n 0 116.1n
+{VCC} 117n {VCC} 117.1n 0 118n 0 118.1n {VCC} 119n {VCC} 119.1n 0 120n 0
+120.1n {VCC} 121n {VCC} 121.1n 0 122n 0 122.1n {VCC} 123n {VCC} 123.1n 0 124n
+0 124.1n {VCC} 125n {VCC} 125.1n 0 126n 0 126.1n {VCC} 127n {VCC} 127.1n 0
+128n 0 128.1n {VCC} 129n {VCC} 129.1n 0 130n 0 130.1n {VCC} 131n {VCC} 131.1n
+0 132n 0 132.1n {VCC} 133n {VCC} 133.1n 0 134n 0 134.1n {VCC} 135n {VCC}
+135.1n 0 136n 0 136.1n {VCC} 137n {VCC} 137.1n 0 138n 0 138.1n {VCC} 139n
+{VCC} 139.1n 0 140n 0 140.1n {VCC} 141n {VCC} 141.1n 0 142n 0 142.1n {VCC}
+143n {VCC} 143.1n 0 144n 0 144.1n {VCC} 145n {VCC} 145.1n 0 146n 0 146.1n
+{VCC} 147n {VCC} 147.1n 0 148n 0 148.1n {VCC} 149n {VCC} 149.1n 0 150n 0
+150.1n {VCC} 151n {VCC} 151.1n 0 152n 0 152.1n {VCC} 153n {VCC} 153.1n 0 154n
+0 154.1n {VCC} 155n {VCC} 155.1n 0 156n 0 156.1n {VCC} 157n {VCC} 157.1n 0
+158n 0 158.1n {VCC} 159n {VCC} 159.1n 0 160n 0 160.1n {VCC} 161n {VCC} 161.1n
+0 162n 0 162.1n {VCC} 163n {VCC} 163.1n 0 164n 0 164.1n {VCC} 165n {VCC}
+165.1n 0 166n 0 166.1n {VCC} 167n {VCC} 167.1n 0 168n 0 168.1n {VCC} 169n
+{VCC} 169.1n 0 170n 0 170.1n {VCC} 171n {VCC} 171.1n 0 172n 0 172.1n {VCC}
+173n {VCC} 173.1n 0 174n 0 174.1n {VCC} 175n {VCC} 175.1n 0 176n 0 176.1n
+{VCC} 177n {VCC} 177.1n 0 178n 0 178.1n {VCC} 179n {VCC} 179.1n 0 180n 0
+180.1n {VCC} 181n {VCC} 181.1n 0 182n 0 182.1n {VCC} 183n {VCC} 183.1n 0 184n
+0 184.1n {VCC} 185n {VCC} 185.1n 0 186n 0 186.1n {VCC} 187n {VCC} 187.1n 0
+188n 0 188.1n {VCC} 189n {VCC} 189.1n 0 190n 0 190.1n {VCC} 191n {VCC} 191.1n
+0 192n 0 192.1n {VCC} 193n {VCC} 193.1n 0 194n 0 194.1n {VCC} 195n {VCC}
+195.1n 0 196n 0 196.1n {VCC} 197n {VCC} 197.1n 0 198n 0 198.1n {VCC} 199n
+{VCC} 199.1n 0 200n 0 200.1n {VCC} 201n {VCC} 201.1n 0 202n 0 202.1n {VCC}
+203n {VCC} 203.1n 0 204n 0 204.1n {VCC} 205n {VCC} 205.1n 0 206n 0 206.1n
+{VCC} 207n {VCC} 207.1n 0 208n 0 208.1n {VCC} 209n {VCC} 209.1n 0 210n 0
+210.1n {VCC} 211n {VCC} 211.1n 0 212n 0 212.1n {VCC} 213n {VCC} 213.1n 0 214n
+0 214.1n {VCC} 215n {VCC} 215.1n 0 216n 0 216.1n {VCC} 217n {VCC} 217.1n 0
+218n 0 218.1n {VCC} 219n {VCC} 219.1n 0 220n 0 220.1n {VCC} 221n {VCC} 221.1n
+0 222n 0 222.1n {VCC} 223n {VCC} 223.1n 0 224n 0 224.1n {VCC} 225n {VCC}
+225.1n 0 226n 0 226.1n {VCC} 227n {VCC} 227.1n 0 228n 0 228.1n {VCC} 229n
+{VCC} 229.1n 0 230n 0 230.1n {VCC} 231n {VCC} 231.1n 0 232n 0 232.1n {VCC}
+233n {VCC} 233.1n 0 234n 0 234.1n {VCC} 235n {VCC} 235.1n 0 236n 0 236.1n
+{VCC} 237n {VCC} 237.1n 0 238n 0 238.1n {VCC} 239n {VCC} 239.1n 0 240n 0
+240.1n {VCC} 241n {VCC} 241.1n 0 242n 0 242.1n {VCC} 243n {VCC} 243.1n 0 244n
+0 244.1n {VCC} 245n {VCC} 245.1n 0 246n 0 246.1n {VCC} 247n {VCC} 247.1n 0
+248n 0 248.1n {VCC} 249n {VCC} 249.1n 0 250n 0 250.1n {VCC} 251n {VCC} 251.1n
+0 252n 0 252.1n {VCC} 253n {VCC} 253.1n 0 254n 0 254.1n {VCC} 255n {VCC}
+255.1n 0 256n 0 256.1n {VCC} 257n {VCC} 257.1n 0 258n 0 258.1n {VCC} 259n
+{VCC} 259.1n 0 260n 0 260.1n {VCC} 261n {VCC} 261.1n 0 262n 0 262.1n {VCC}
+263n {VCC} 263.1n 0 264n 0 264.1n {VCC} 265n {VCC} 265.1n 0 266n 0 266.1n
+{VCC} 267n {VCC} 267.1n 0 268n 0 268.1n {VCC} 269n {VCC} 269.1n 0 270n 0
+270.1n {VCC} 271n {VCC} 271.1n 0 272n 0 272.1n {VCC} 273n {VCC} 273.1n 0 274n
+0 274.1n {VCC} 275n {VCC} 275.1n 0 276n 0 276.1n {VCC} 277n {VCC} 277.1n 0
+278n 0 278.1n {VCC} 279n {VCC} 279.1n 0 280n 0 280.1n {VCC} 281n {VCC} 281.1n
+0 282n 0 282.1n {VCC} 283n {VCC} 283.1n 0 284n 0 284.1n {VCC} 285n {VCC}
+285.1n 0 286n 0 286.1n {VCC} 287n {VCC} 287.1n 0 288n 0 288.1n {VCC} 289n
+{VCC} 289.1n 0 290n 0 290.1n {VCC} 291n {VCC} 291.1n 0 292n 0 292.1n {VCC}
+293n {VCC} 293.1n 0 294n 0 294.1n {VCC} 295n {VCC} 295.1n 0 296n 0 296.1n
+{VCC} 297n {VCC} 297.1n 0 298n 0 298.1n {VCC} 299n {VCC} 299.1n 0 300n 0
+300.1n {VCC} 301n {VCC} 301.1n 0 302n 0 302.1n {VCC} 303n {VCC} 303.1n 0 304n
+0 304.1n {VCC} 305n {VCC} 305.1n 0 306n 0 306.1n {VCC} 307n {VCC} 307.1n 0
+308n 0 308.1n {VCC} 309n {VCC} 309.1n 0 310n 0 310.1n {VCC} 311n {VCC} 311.1n
+0 312n 0 312.1n {VCC} 313n {VCC} 313.1n 0 314n 0 314.1n {VCC} 315n {VCC}
+315.1n 0 316n 0 316.1n {VCC} 317n {VCC} 317.1n 0 318n 0 318.1n {VCC} 319n
+{VCC} 319.1n 0 320n 0 320.1n {VCC} 321n {VCC} 321.1n 0 322n 0 322.1n {VCC}
+323n {VCC} 323.1n 0 324n 0 324.1n {VCC} 325n {VCC} 325.1n 0 326n 0 326.1n
+{VCC} 327n {VCC} 327.1n 0 328n 0 328.1n {VCC} 329n {VCC} 329.1n 0 330n 0
+330.1n {VCC} 331n {VCC} 331.1n 0 332n 0 332.1n {VCC} 333n {VCC} 333.1n 0 334n
+0 334.1n {VCC} 335n {VCC} 335.1n 0 336n 0 336.1n {VCC} 337n {VCC} 337.1n 0
+338n 0 338.1n {VCC} 339n {VCC} 339.1n 0 340n 0 340.1n {VCC} 341n {VCC} 341.1n
+0 342n 0 342.1n {VCC} 343n {VCC} 343.1n 0 344n 0 344.1n {VCC} 345n {VCC}
+345.1n 0 346n 0 346.1n {VCC} 347n {VCC} 347.1n 0 348n 0 348.1n {VCC} 349n
+{VCC} 349.1n 0 350n 0 350.1n {VCC} 351n {VCC} 351.1n 0 352n 0 352.1n {VCC}
+353n {VCC} 353.1n 0 354n 0 354.1n {VCC} 355n {VCC} 355.1n 0 356n 0 356.1n
+{VCC} 357n {VCC} 357.1n 0 358n 0 358.1n {VCC} 359n {VCC} 359.1n 0 360n 0
+360.1n {VCC} 361n {VCC} 361.1n 0 362n 0 362.1n {VCC} 363n {VCC} 363.1n 0 364n
+0 364.1n {VCC} 365n {VCC} 365.1n 0 366n 0 366.1n {VCC} 367n {VCC} 367.1n 0
+368n 0 368.1n {VCC} 369n {VCC} 369.1n 0 370n 0 370.1n {VCC} 371n {VCC} 371.1n
+0 372n 0 372.1n {VCC} 373n {VCC} 373.1n 0 374n 0 374.1n {VCC} 375n {VCC}
+375.1n 0 376n 0 376.1n {VCC} 377n {VCC} 377.1n 0 378n 0 378.1n {VCC} 379n
+{VCC} 379.1n 0 380n 0 380.1n {VCC} 381n {VCC} 381.1n 0 382n 0 382.1n {VCC}
+383n {VCC} 383.1n 0 384n 0 384.1n {VCC} 385n {VCC} 385.1n 0 386n 0 386.1n
+{VCC} 387n {VCC} 387.1n 0 388n 0 388.1n {VCC} 389n {VCC} 389.1n 0 390n 0
+390.1n {VCC} 391n {VCC} 391.1n 0 392n 0 392.1n {VCC} 393n {VCC} 393.1n 0 394n
+0 394.1n {VCC} 395n {VCC} 395.1n 0 396n 0 396.1n {VCC} 397n {VCC} 397.1n 0
+398n 0 398.1n {VCC} 399n {VCC} 399.1n 0 400n 0 400.1n {VCC} 401n {VCC} 401.1n
+0 402n 0 402.1n {VCC} 403n {VCC} 403.1n 0 404n 0 404.1n {VCC} 405n {VCC}
+405.1n 0 406n 0 406.1n {VCC} 407n {VCC} 407.1n 0 408n 0 408.1n {VCC} 409n
+{VCC} 409.1n 0 410n 0 410.1n {VCC} 411n {VCC} 411.1n 0 412n 0 412.1n {VCC}
+413n {VCC} 413.1n 0 414n 0 414.1n {VCC} 415n {VCC} 415.1n 0 416n 0 416.1n
+{VCC} 417n {VCC} 417.1n 0 418n 0 418.1n {VCC} 419n {VCC} 419.1n 0 420n 0
+420.1n {VCC} 421n {VCC} 421.1n 0 422n 0 422.1n {VCC} 423n {VCC} 423.1n 0 424n
+0 424.1n {VCC} 425n {VCC} 425.1n 0 426n 0 426.1n {VCC} 427n {VCC} 427.1n 0
+428n 0 428.1n {VCC} 429n {VCC} 429.1n 0 430n 0 430.1n {VCC} 431n {VCC} 431.1n
+0 432n 0 432.1n {VCC} 433n {VCC} 433.1n 0 434n 0 434.1n {VCC} 435n {VCC}
+435.1n 0 436n 0 436.1n {VCC} 437n {VCC} 437.1n 0 438n 0 438.1n {VCC} 439n
+{VCC} 439.1n 0 440n 0 440.1n {VCC} 441n {VCC} 441.1n 0 442n 0 442.1n {VCC}
+443n {VCC} 443.1n 0 444n 0 444.1n {VCC} 445n {VCC} 445.1n 0 446n 0 446.1n
+{VCC} 447n {VCC} 447.1n 0 448n 0 448.1n {VCC} 449n {VCC} 449.1n 0 450n 0
+450.1n {VCC} 451n {VCC} 451.1n 0 452n 0 452.1n {VCC} 453n {VCC} 453.1n 0 454n
+0 454.1n {VCC} 455n {VCC} 455.1n 0 456n 0 456.1n {VCC} 457n {VCC} 457.1n 0
+458n 0 458.1n {VCC} 459n {VCC} 459.1n 0 460n 0 460.1n {VCC} 461n {VCC} 461.1n
+0 462n 0 462.1n {VCC} 463n {VCC} 463.1n 0 464n 0 464.1n {VCC} 465n {VCC}
+465.1n 0 466n 0 466.1n {VCC} 467n {VCC} 467.1n 0 468n 0 468.1n {VCC} 469n
+{VCC} 469.1n 0 470n 0 470.1n {VCC} 471n {VCC} 471.1n 0 472n 0 472.1n {VCC}
+473n {VCC} 473.1n 0 474n 0 474.1n {VCC} 475n {VCC} 475.1n 0 476n 0 476.1n
+{VCC} 477n {VCC} 477.1n 0 478n 0 478.1n {VCC} 479n {VCC} 479.1n 0 480n 0
+480.1n {VCC} 481n {VCC} 481.1n 0 482n 0 482.1n {VCC} 483n {VCC} 483.1n 0 484n
+0 484.1n {VCC} 485n {VCC} 485.1n 0 486n 0 486.1n {VCC} 487n {VCC} 487.1n 0
+488n 0 488.1n {VCC} 489n {VCC} 489.1n 0 490n 0 490.1n {VCC} 491n {VCC} 491.1n
+0 492n 0 492.1n {VCC} 493n {VCC} 493.1n 0 494n 0 494.1n {VCC} 495n {VCC}
+495.1n 0 496n 0 496.1n {VCC} 497n {VCC} 497.1n 0 498n 0 498.1n {VCC} 499n
+{VCC} 499.1n 0 500n 0 500.1n {VCC} 501n {VCC} 501.1n 0 502n 0 502.1n {VCC}
+503n {VCC} 503.1n 0 504n 0 504.1n {VCC} 505n {VCC} 505.1n 0 506n 0 506.1n
+{VCC} 507n {VCC} 507.1n 0 508n 0 508.1n {VCC} 509n {VCC} 509.1n 0 510n 0
+510.1n {VCC} 511n {VCC} 511.1n 0 512n 0 512.1n {VCC} 513n {VCC} 513.1n 0 514n
+0 514.1n {VCC} 515n {VCC} 515.1n 0 516n 0 516.1n {VCC} 517n {VCC} 517.1n 0
+518n 0 518.1n {VCC} 519n {VCC} 519.1n 0 520n 0 520.1n {VCC} 521n {VCC} 521.1n
+0 522n 0 522.1n {VCC} 523n {VCC} 523.1n 0 524n 0 524.1n {VCC} 525n {VCC}
+525.1n 0 526n 0 526.1n {VCC} 527n {VCC} 527.1n 0 528n 0 528.1n {VCC} 529n
+{VCC} 529.1n 0 530n 0 530.1n {VCC} 531n {VCC} 531.1n 0 532n 0 532.1n {VCC}
+533n {VCC} 533.1n 0 534n 0 534.1n {VCC} 535n {VCC} 535.1n 0 536n 0 536.1n
+{VCC} 537n {VCC} 537.1n 0 538n 0 538.1n {VCC} 539n {VCC} 539.1n 0 540n 0
+540.1n {VCC} 541n {VCC} 541.1n 0 542n 0 542.1n {VCC} 543n {VCC} 543.1n 0 544n
+0 544.1n {VCC} 545n {VCC} 545.1n 0 546n 0 546.1n {VCC} 547n {VCC} 547.1n 0
+548n 0 548.1n {VCC} 549n {VCC} 549.1n 0 550n 0 550.1n {VCC} 551n {VCC} 551.1n
+0 552n 0 552.1n {VCC} 553n {VCC} 553.1n 0 554n 0 554.1n {VCC} 555n {VCC}
+555.1n 0 556n 0 556.1n {VCC} 557n {VCC} 557.1n 0 558n 0 558.1n {VCC} 559n
+{VCC} 559.1n 0 560n 0 560.1n {VCC} 561n {VCC} 561.1n 0 562n 0 562.1n {VCC}
+563n {VCC} 563.1n 0 564n 0 564.1n {VCC} 565n {VCC} 565.1n 0 566n 0 566.1n
+{VCC} 567n {VCC} 567.1n 0 568n 0 568.1n {VCC} 569n {VCC} 569.1n 0 570n 0
+570.1n {VCC} 571n {VCC} 571.1n 0 572n 0 572.1n {VCC} 573n {VCC} 573.1n 0 574n
+0 574.1n {VCC} 575n {VCC} 575.1n 0 576n 0 576.1n {VCC} 577n {VCC} 577.1n 0
+578n 0 578.1n {VCC} 579n {VCC} 579.1n 0 580n 0 580.1n {VCC} 581n {VCC} 581.1n
+0 582n 0 582.1n {VCC} 583n {VCC} 583.1n 0 584n 0 584.1n {VCC} 585n {VCC}
+585.1n 0 586n 0 586.1n {VCC} 587n {VCC} 587.1n 0 588n 0 588.1n {VCC} 589n
+{VCC} 589.1n 0 590n 0 590.1n {VCC} 591n {VCC} 591.1n 0 592n 0 592.1n {VCC}
+593n {VCC} 593.1n 0 594n 0 594.1n {VCC} 595n {VCC} 595.1n 0 596n 0 596.1n
+{VCC} 597n {VCC} 597.1n 0 598n 0 598.1n {VCC} 599n {VCC} 599.1n 0 600n 0
+600.1n {VCC} 601n {VCC} 601.1n 0 602n 0 602.1n {VCC} 603n {VCC} 603.1n 0 604n
+0 604.1n {VCC} 605n {VCC} 605.1n 0 606n 0 606.1n {VCC} 607n {VCC} 607.1n 0
+608n 0 608.1n {VCC} 609n {VCC} 609.1n 0 610n 0 610.1n {VCC} 611n {VCC} 611.1n
+0 612n 0 612.1n {VCC} 613n {VCC} 613.1n 0 614n 0 614.1n {VCC} 615n {VCC}
+615.1n 0 616n 0 616.1n {VCC} 617n {VCC} 617.1n 0 618n 0 618.1n {VCC} 619n
+{VCC} 619.1n 0 620n 0 620.1n {VCC} 621n {VCC} 621.1n 0 622n 0 622.1n {VCC}
+623n {VCC} 623.1n 0 624n 0 624.1n {VCC} 625n {VCC} 625.1n 0 626n 0 626.1n
+{VCC} 627n {VCC} 627.1n 0 628n 0 628.1n {VCC} 629n {VCC} 629.1n 0 630n 0
+630.1n {VCC} 631n {VCC} 631.1n 0 632n 0 632.1n {VCC} 633n {VCC} 633.1n 0 634n
+0 634.1n {VCC} 635n {VCC} 635.1n 0 636n 0 636.1n {VCC} 637n {VCC} 637.1n 0
+638n 0 638.1n {VCC} 639n {VCC} 639.1n 0 640n 0 640.1n {VCC} 641n {VCC} 641.1n
+0 642n 0 642.1n {VCC} 643n {VCC} 643.1n 0 644n 0 644.1n {VCC} 645n {VCC}
+645.1n 0 646n 0 646.1n {VCC} 647n {VCC} 647.1n 0 648n 0 648.1n {VCC} 649n
+{VCC} 649.1n 0 650n 0 650.1n {VCC} 651n {VCC} 651.1n 0 652n 0 652.1n {VCC}
+653n {VCC} 653.1n 0 654n 0 654.1n {VCC} 655n {VCC} 655.1n 0 656n 0 656.1n
+{VCC} 657n {VCC} 657.1n 0 658n 0 658.1n {VCC} 659n {VCC} 659.1n 0 660n 0
+660.1n {VCC} 661n {VCC} 661.1n 0 662n 0 662.1n {VCC} 663n {VCC} 663.1n 0 664n
+0 664.1n {VCC} 665n {VCC} 665.1n 0 666n 0 666.1n {VCC} 667n {VCC} 667.1n 0
+668n 0 668.1n {VCC} 669n {VCC} 669.1n 0 670n 0 670.1n {VCC} 671n {VCC} 671.1n
+0 672n 0 672.1n {VCC} 673n {VCC} 673.1n 0 674n 0 674.1n {VCC} 675n {VCC}
+675.1n 0 676n 0 676.1n {VCC} 677n {VCC} 677.1n 0 678n 0 678.1n {VCC} 679n
+{VCC} 679.1n 0 680n 0 680.1n {VCC} 681n {VCC} 681.1n 0 682n 0 682.1n {VCC}
+683n {VCC} 683.1n 0 684n 0 684.1n {VCC} 685n {VCC} 685.1n 0 686n 0 686.1n
+{VCC} 687n {VCC} 687.1n 0 688n 0 688.1n {VCC} 689n {VCC} 689.1n 0 690n 0
+690.1n {VCC} 691n {VCC} 691.1n 0 692n 0 692.1n {VCC} 693n {VCC} 693.1n 0 694n
+0 694.1n {VCC} 695n {VCC} 695.1n 0 696n 0 696.1n {VCC} 697n {VCC} 697.1n 0
+698n 0 698.1n {VCC} 699n {VCC} 699.1n 0 700n 0 700.1n {VCC} 701n {VCC} 701.1n
+0 702n 0 702.1n {VCC} 703n {VCC} 703.1n 0 704n 0 704.1n {VCC} 705n {VCC}
+705.1n 0 706n 0 706.1n {VCC} 707n {VCC} 707.1n 0 708n 0 708.1n {VCC} 709n
+{VCC} 709.1n 0 710n 0 710.1n {VCC} 711n {VCC} 711.1n 0 712n 0 712.1n {VCC}
+713n {VCC} 713.1n 0 714n 0 714.1n {VCC} 715n {VCC} 715.1n 0 716n 0 716.1n
+{VCC} 717n {VCC} 717.1n 0 718n 0 718.1n {VCC} 719n {VCC} 719.1n 0 720n 0
+720.1n {VCC} 721n {VCC} 721.1n 0 722n 0 722.1n {VCC} 723n {VCC} 723.1n 0 724n
+0 724.1n {VCC} 725n {VCC} 725.1n 0 726n 0 726.1n {VCC} 727n {VCC} 727.1n 0
+728n 0 728.1n {VCC} 729n {VCC} 729.1n 0 730n 0 730.1n {VCC} 731n {VCC} 731.1n
+0 732n 0 732.1n {VCC} 733n {VCC} 733.1n 0 734n 0 734.1n {VCC} 735n {VCC}
+735.1n 0 736n 0 736.1n {VCC} 737n {VCC} 737.1n 0 738n 0 738.1n {VCC} 739n
+{VCC} 739.1n 0 740n 0 740.1n {VCC} 741n {VCC} 741.1n 0 742n 0 742.1n {VCC}
+743n {VCC} 743.1n 0 744n 0 744.1n {VCC} 745n {VCC} 745.1n 0 746n 0 746.1n
+{VCC} 747n {VCC} 747.1n 0 748n 0 748.1n {VCC} 749n {VCC} 749.1n 0 750n 0
+750.1n {VCC} 751n {VCC} 751.1n 0 752n 0 752.1n {VCC} 753n {VCC} 753.1n 0 754n
+0 754.1n {VCC} 755n {VCC} 755.1n 0 756n 0 756.1n {VCC} 757n {VCC} 757.1n 0
+758n 0 758.1n {VCC} 759n {VCC} 759.1n 0 760n 0 760.1n {VCC} 761n {VCC} 761.1n
+0 762n 0 762.1n {VCC} 763n {VCC} 763.1n 0 764n 0 764.1n {VCC} 765n {VCC}
+765.1n 0 766n 0 766.1n {VCC} 767n {VCC} 767.1n 0 768n 0 768.1n {VCC} 769n
+{VCC} 769.1n 0 770n 0 770.1n {VCC} 771n {VCC} 771.1n 0 772n 0 772.1n {VCC}
+773n {VCC} 773.1n 0 774n 0 774.1n {VCC} 775n {VCC} 775.1n 0 776n 0 776.1n
+{VCC} 777n {VCC} 777.1n 0 778n 0 778.1n {VCC} 779n {VCC} 779.1n 0 780n 0
+780.1n {VCC} 781n {VCC} 781.1n 0 782n 0 782.1n {VCC} 783n {VCC} 783.1n 0 784n
+0 784.1n {VCC} 785n {VCC} 785.1n 0 786n 0 786.1n {VCC} 787n {VCC} 787.1n 0
+788n 0 788.1n {VCC} 789n {VCC} 789.1n 0 790n 0 790.1n {VCC} 791n {VCC} 791.1n
+0 792n 0 792.1n {VCC} 793n {VCC} 793.1n 0 794n 0 794.1n {VCC} 795n {VCC}
+795.1n 0 796n 0 796.1n {VCC} 797n {VCC} 797.1n 0 798n 0 798.1n {VCC} 799n
+{VCC} 799.1n 0 800n 0 800.1n {VCC} 801n {VCC} 801.1n 0 802n 0 802.1n {VCC}
+803n {VCC} 803.1n 0 804n 0 804.1n {VCC} 805n {VCC} 805.1n 0 806n 0 806.1n
+{VCC} 807n {VCC} 807.1n 0 808n 0 808.1n {VCC} 809n {VCC} 809.1n 0 810n 0
+810.1n {VCC} 811n {VCC} 811.1n 0 812n 0 812.1n {VCC} 813n {VCC} 813.1n 0 814n
+0 814.1n {VCC} 815n {VCC} 815.1n 0 816n 0 816.1n {VCC} 817n {VCC} 817.1n 0
+818n 0 818.1n {VCC} 819n {VCC} 819.1n 0 820n 0 820.1n {VCC} 821n {VCC} 821.1n
+0 822n 0 822.1n {VCC} 823n {VCC} 823.1n 0 824n 0 824.1n {VCC} 825n {VCC}
+825.1n 0 826n 0 826.1n {VCC} 827n {VCC} 827.1n 0 828n 0 828.1n {VCC} 829n
+{VCC} 829.1n 0 830n 0 830.1n {VCC} 831n {VCC} 831.1n 0 832n 0 832.1n {VCC}
+833n {VCC} 833.1n 0 834n 0 834.1n {VCC} 835n {VCC} 835.1n 0 836n 0 836.1n
+{VCC} 837n {VCC} 837.1n 0 838n 0 838.1n {VCC} 839n {VCC} 839.1n 0 840n 0
+840.1n {VCC} 841n {VCC} 841.1n 0 842n 0 842.1n {VCC} 843n {VCC} 843.1n 0 844n
+0 844.1n {VCC} 845n {VCC} 845.1n 0 846n 0 846.1n {VCC} 847n {VCC} 847.1n 0
+848n 0 848.1n {VCC} 849n {VCC} 849.1n 0 850n 0 850.1n {VCC} 851n {VCC} 851.1n
+0 852n 0 852.1n {VCC} 853n {VCC} 853.1n 0 854n 0 854.1n {VCC} 855n {VCC}
+855.1n 0 856n 0 856.1n {VCC} 857n {VCC} 857.1n 0 858n 0 858.1n {VCC} 859n
+{VCC} 859.1n 0 860n 0 860.1n {VCC} 861n {VCC} 861.1n 0 862n 0 862.1n {VCC}
+863n {VCC} 863.1n 0 864n 0 864.1n {VCC} 865n {VCC} 865.1n 0 866n 0 866.1n
+{VCC} 867n {VCC} 867.1n 0 868n 0 868.1n {VCC} 869n {VCC} 869.1n 0 870n 0
+870.1n {VCC} 871n {VCC} 871.1n 0 872n 0 872.1n {VCC} 873n {VCC} 873.1n 0 874n
+0 874.1n {VCC} 875n {VCC} 875.1n 0 876n 0 876.1n {VCC} 877n {VCC} 877.1n 0
+878n 0 878.1n {VCC} 879n {VCC} 879.1n 0 880n 0 880.1n {VCC} 881n {VCC} 881.1n
+0 882n 0 882.1n {VCC} 883n {VCC} 883.1n 0 884n 0 884.1n {VCC} 885n {VCC}
+885.1n 0 886n 0 886.1n {VCC} 887n {VCC} 887.1n 0 888n 0 888.1n {VCC} 889n
+{VCC} 889.1n 0 890n 0 890.1n {VCC} 891n {VCC} 891.1n 0 892n 0 892.1n {VCC}
+893n {VCC} 893.1n 0 894n 0 894.1n {VCC} 895n {VCC} 895.1n 0 896n 0 896.1n
+{VCC} 897n {VCC} 897.1n 0 898n 0 898.1n {VCC} 899n {VCC} 899.1n 0 900n 0
+900.1n {VCC} 901n {VCC} 901.1n 0 902n 0 902.1n {VCC} 903n {VCC} 903.1n 0 904n
+0 904.1n {VCC} 905n {VCC} 905.1n 0 906n 0 906.1n {VCC} 907n {VCC} 907.1n 0
+908n 0 908.1n {VCC} 909n {VCC} 909.1n 0 910n 0 910.1n {VCC} 911n {VCC} 911.1n
+0 912n 0 912.1n {VCC} 913n {VCC} 913.1n 0 914n 0 914.1n {VCC} 915n {VCC}
+915.1n 0 916n 0 916.1n {VCC} 917n {VCC} 917.1n 0 918n 0 918.1n {VCC} 919n
+{VCC} 919.1n 0 920n 0 920.1n {VCC} 921n {VCC} 921.1n 0 922n 0 922.1n {VCC}
+923n {VCC} 923.1n 0 924n 0 924.1n {VCC} 925n {VCC} 925.1n 0 926n 0 926.1n
+{VCC} 927n {VCC} 927.1n 0 928n 0 928.1n {VCC} 929n {VCC} 929.1n 0 930n 0
+930.1n {VCC} 931n {VCC} 931.1n 0 932n 0 932.1n {VCC} 933n {VCC} 933.1n 0 934n
+0 934.1n {VCC} 935n {VCC} 935.1n 0 936n 0 936.1n {VCC} 937n {VCC} 937.1n 0
+938n 0 938.1n {VCC} 939n {VCC} 939.1n 0 940n 0 940.1n {VCC} 941n {VCC} 941.1n
+0 942n 0 942.1n {VCC} 943n {VCC} 943.1n 0 944n 0 944.1n {VCC} 945n {VCC}
+945.1n 0 946n 0 946.1n {VCC} 947n {VCC} 947.1n 0 948n 0 948.1n {VCC} 949n
+{VCC} 949.1n 0 950n 0 950.1n {VCC} 951n {VCC} 951.1n 0 952n 0 952.1n {VCC}
+953n {VCC} 953.1n 0 954n 0 954.1n {VCC} 955n {VCC} 955.1n 0 956n 0 956.1n
+{VCC} 957n {VCC} 957.1n 0 958n 0 958.1n {VCC} 959n {VCC} 959.1n 0 960n 0
+960.1n {VCC} 961n {VCC} 961.1n 0 962n 0 962.1n {VCC} 963n {VCC} 963.1n 0 964n
+0 964.1n {VCC} 965n {VCC} 965.1n 0 966n 0 966.1n {VCC} 967n {VCC} 967.1n 0
+968n 0 968.1n {VCC} 969n {VCC} 969.1n 0 970n 0 970.1n {VCC} 971n {VCC} 971.1n
+0 972n 0 972.1n {VCC} 973n {VCC} 973.1n 0 974n 0 974.1n {VCC} 975n {VCC}
+975.1n 0 976n 0 976.1n {VCC} 977n {VCC} 977.1n 0 978n 0 978.1n {VCC} 979n
+{VCC} 979.1n 0 980n 0 980.1n {VCC} 981n {VCC} 981.1n 0 982n 0 982.1n {VCC}
+983n {VCC} 983.1n 0 984n 0 984.1n {VCC} 985n {VCC} 985.1n 0 986n 0 986.1n
+{VCC} 987n {VCC} 987.1n 0 988n 0 988.1n {VCC} 989n {VCC} 989.1n 0 990n 0
+990.1n {VCC} 991n {VCC} 991.1n 0 992n 0 992.1n {VCC} 993n {VCC} 993.1n 0 994n
+0 994.1n {VCC} 995n {VCC} 995.1n 0 996n 0 996.1n {VCC} 997n {VCC} 997.1n 0
+998n 0 998.1n {VCC} 999n {VCC} 999.1n 0 1000n 0 1000.1n {VCC} 1001n {VCC} 1001.1n
+0 1002n 0 1002.1n {VCC} 1003n {VCC} 1003.1n 0 1004n 0 1004.1n {VCC} 1005n {VCC}
+1005.1n 0 1006n 0 1006.1n {VCC} 1007n {VCC} 1007.1n 0 1008n 0 1008.1n {VCC} 1009n
+{VCC} 1009.1n 0 1010n 0 1010.1n {VCC} 1011n {VCC} 1011.1n 0 1012n 0 1012.1n {VCC}
+1013n {VCC} 1013.1n 0 1014n 0 1014.1n {VCC} 1015n {VCC} 1015.1n 0 1016n 0 1016.1n
+{VCC} 1017n {VCC} 1017.1n 0 1018n 0 1018.1n {VCC} 1019n {VCC} 1019.1n 0 1020n 0
+1020.1n {VCC} 1021n {VCC} 1021.1n 0 1022n 0 1022.1n {VCC} 1023n {VCC} 1023.1n 0 1024n
+0 1024.1n {VCC}
VA[3] A[3] 0 PWL 1n 0 3n 0 3.1n {VCC} 5n {VCC} 5.1n 0 7n
+0 7.1n {VCC} 9n {VCC} 9.1n 0 11n 0 11.1n {VCC} 13n {VCC} 13.1n 0
+15n 0 15.1n {VCC} 17n {VCC} 17.1n 0 19n 0 19.1n {VCC} 21n {VCC} 21.1n
+0 23n 0 23.1n {VCC} 25n {VCC} 25.1n 0 27n 0 27.1n {VCC} 29n {VCC}
+29.1n 0 31n 0 31.1n {VCC} 33n {VCC} 33.1n 0 35n 0 35.1n {VCC} 37n
+{VCC} 37.1n 0 39n 0 39.1n {VCC} 41n {VCC} 41.1n 0 43n 0 43.1n {VCC}
+45n {VCC} 45.1n 0 47n 0 47.1n {VCC} 49n {VCC} 49.1n 0 51n 0 51.1n
+{VCC} 53n {VCC} 53.1n 0 55n 0 55.1n {VCC} 57n {VCC} 57.1n 0 59n 0
+59.1n {VCC} 61n {VCC} 61.1n 0 63n 0 63.1n {VCC} 65n {VCC} 65.1n 0 67n
+0 67.1n {VCC} 69n {VCC} 69.1n 0 71n 0 71.1n {VCC} 73n {VCC} 73.1n 0
+75n 0 75.1n {VCC} 77n {VCC} 77.1n 0 79n 0 79.1n {VCC} 81n {VCC} 81.1n
+0 83n 0 83.1n {VCC} 85n {VCC} 85.1n 0 87n 0 87.1n {VCC} 89n {VCC}
+89.1n 0 91n 0 91.1n {VCC} 93n {VCC} 93.1n 0 95n 0 95.1n {VCC} 97n
+{VCC} 97.1n 0 99n 0 99.1n {VCC} 101n {VCC} 101.1n 0 103n 0 103.1n {VCC}
+105n {VCC} 105.1n 0 107n 0 107.1n {VCC} 109n {VCC} 109.1n 0 111n 0 111.1n
+{VCC} 113n {VCC} 113.1n 0 115n 0 115.1n {VCC} 117n {VCC} 117.1n 0 119n 0
+119.1n {VCC} 121n {VCC} 121.1n 0 123n 0 123.1n {VCC} 125n {VCC} 125.1n 0 127n
+0 127.1n {VCC} 129n {VCC} 129.1n 0 131n 0 131.1n {VCC} 133n {VCC} 133.1n 0
+135n 0 135.1n {VCC} 137n {VCC} 137.1n 0 139n 0 139.1n {VCC} 141n {VCC} 141.1n
+0 143n 0 143.1n {VCC} 145n {VCC} 145.1n 0 147n 0 147.1n {VCC} 149n {VCC}
+149.1n 0 151n 0 151.1n {VCC} 153n {VCC} 153.1n 0 155n 0 155.1n {VCC} 157n
+{VCC} 157.1n 0 159n 0 159.1n {VCC} 161n {VCC} 161.1n 0 163n 0 163.1n {VCC}
+165n {VCC} 165.1n 0 167n 0 167.1n {VCC} 169n {VCC} 169.1n 0 171n 0 171.1n
+{VCC} 173n {VCC} 173.1n 0 175n 0 175.1n {VCC} 177n {VCC} 177.1n 0 179n 0
+179.1n {VCC} 181n {VCC} 181.1n 0 183n 0 183.1n {VCC} 185n {VCC} 185.1n 0 187n
+0 187.1n {VCC} 189n {VCC} 189.1n 0 191n 0 191.1n {VCC} 193n {VCC} 193.1n 0
+195n 0 195.1n {VCC} 197n {VCC} 197.1n 0 199n 0 199.1n {VCC} 201n {VCC} 201.1n
+0 203n 0 203.1n {VCC} 205n {VCC} 205.1n 0 207n 0 207.1n {VCC} 209n {VCC}
+209.1n 0 211n 0 211.1n {VCC} 213n {VCC} 213.1n 0 215n 0 215.1n {VCC} 217n
+{VCC} 217.1n 0 219n 0 219.1n {VCC} 221n {VCC} 221.1n 0 223n 0 223.1n {VCC}
+225n {VCC} 225.1n 0 227n 0 227.1n {VCC} 229n {VCC} 229.1n 0 231n 0 231.1n
+{VCC} 233n {VCC} 233.1n 0 235n 0 235.1n {VCC} 237n {VCC} 237.1n 0 239n 0
+239.1n {VCC} 241n {VCC} 241.1n 0 243n 0 243.1n {VCC} 245n {VCC} 245.1n 0 247n
+0 247.1n {VCC} 249n {VCC} 249.1n 0 251n 0 251.1n {VCC} 253n {VCC} 253.1n 0
+255n 0 255.1n {VCC} 257n {VCC} 257.1n 0 259n 0 259.1n {VCC} 261n {VCC} 261.1n
+0 263n 0 263.1n {VCC} 265n {VCC} 265.1n 0 267n 0 267.1n {VCC} 269n {VCC}
+269.1n 0 271n 0 271.1n {VCC} 273n {VCC} 273.1n 0 275n 0 275.1n {VCC} 277n
+{VCC} 277.1n 0 279n 0 279.1n {VCC} 281n {VCC} 281.1n 0 283n 0 283.1n {VCC}
+285n {VCC} 285.1n 0 287n 0 287.1n {VCC} 289n {VCC} 289.1n 0 291n 0 291.1n
+{VCC} 293n {VCC} 293.1n 0 295n 0 295.1n {VCC} 297n {VCC} 297.1n 0 299n 0
+299.1n {VCC} 301n {VCC} 301.1n 0 303n 0 303.1n {VCC} 305n {VCC} 305.1n 0 307n
+0 307.1n {VCC} 309n {VCC} 309.1n 0 311n 0 311.1n {VCC} 313n {VCC} 313.1n 0
+315n 0 315.1n {VCC} 317n {VCC} 317.1n 0 319n 0 319.1n {VCC} 321n {VCC} 321.1n
+0 323n 0 323.1n {VCC} 325n {VCC} 325.1n 0 327n 0 327.1n {VCC} 329n {VCC}
+329.1n 0 331n 0 331.1n {VCC} 333n {VCC} 333.1n 0 335n 0 335.1n {VCC} 337n
+{VCC} 337.1n 0 339n 0 339.1n {VCC} 341n {VCC} 341.1n 0 343n 0 343.1n {VCC}
+345n {VCC} 345.1n 0 347n 0 347.1n {VCC} 349n {VCC} 349.1n 0 351n 0 351.1n
+{VCC} 353n {VCC} 353.1n 0 355n 0 355.1n {VCC} 357n {VCC} 357.1n 0 359n 0
+359.1n {VCC} 361n {VCC} 361.1n 0 363n 0 363.1n {VCC} 365n {VCC} 365.1n 0 367n
+0 367.1n {VCC} 369n {VCC} 369.1n 0 371n 0 371.1n {VCC} 373n {VCC} 373.1n 0
+375n 0 375.1n {VCC} 377n {VCC} 377.1n 0 379n 0 379.1n {VCC} 381n {VCC} 381.1n
+0 383n 0 383.1n {VCC} 385n {VCC} 385.1n 0 387n 0 387.1n {VCC} 389n {VCC}
+389.1n 0 391n 0 391.1n {VCC} 393n {VCC} 393.1n 0 395n 0 395.1n {VCC} 397n
+{VCC} 397.1n 0 399n 0 399.1n {VCC} 401n {VCC} 401.1n 0 403n 0 403.1n {VCC}
+405n {VCC} 405.1n 0 407n 0 407.1n {VCC} 409n {VCC} 409.1n 0 411n 0 411.1n
+{VCC} 413n {VCC} 413.1n 0 415n 0 415.1n {VCC} 417n {VCC} 417.1n 0 419n 0
+419.1n {VCC} 421n {VCC} 421.1n 0 423n 0 423.1n {VCC} 425n {VCC} 425.1n 0 427n
+0 427.1n {VCC} 429n {VCC} 429.1n 0 431n 0 431.1n {VCC} 433n {VCC} 433.1n 0
+435n 0 435.1n {VCC} 437n {VCC} 437.1n 0 439n 0 439.1n {VCC} 441n {VCC} 441.1n
+0 443n 0 443.1n {VCC} 445n {VCC} 445.1n 0 447n 0 447.1n {VCC} 449n {VCC}
+449.1n 0 451n 0 451.1n {VCC} 453n {VCC} 453.1n 0 455n 0 455.1n {VCC} 457n
+{VCC} 457.1n 0 459n 0 459.1n {VCC} 461n {VCC} 461.1n 0 463n 0 463.1n {VCC}
+465n {VCC} 465.1n 0 467n 0 467.1n {VCC} 469n {VCC} 469.1n 0 471n 0 471.1n
+{VCC} 473n {VCC} 473.1n 0 475n 0 475.1n {VCC} 477n {VCC} 477.1n 0 479n 0
+479.1n {VCC} 481n {VCC} 481.1n 0 483n 0 483.1n {VCC} 485n {VCC} 485.1n 0 487n
+0 487.1n {VCC} 489n {VCC} 489.1n 0 491n 0 491.1n {VCC} 493n {VCC} 493.1n 0
+495n 0 495.1n {VCC} 497n {VCC} 497.1n 0 499n 0 499.1n {VCC} 501n {VCC} 501.1n
+0 503n 0 503.1n {VCC} 505n {VCC} 505.1n 0 507n 0 507.1n {VCC} 509n {VCC}
+509.1n 0 511n 0 511.1n {VCC} 513n {VCC} 513.1n 0 515n 0 515.1n {VCC} 517n
+{VCC} 517.1n 0 519n 0 519.1n {VCC} 521n {VCC} 521.1n 0 523n 0 523.1n {VCC}
+525n {VCC} 525.1n 0 527n 0 527.1n {VCC} 529n {VCC} 529.1n 0 531n 0 531.1n
+{VCC} 533n {VCC} 533.1n 0 535n 0 535.1n {VCC} 537n {VCC} 537.1n 0 539n 0
+539.1n {VCC} 541n {VCC} 541.1n 0 543n 0 543.1n {VCC} 545n {VCC} 545.1n 0 547n
+0 547.1n {VCC} 549n {VCC} 549.1n 0 551n 0 551.1n {VCC} 553n {VCC} 553.1n 0
+555n 0 555.1n {VCC} 557n {VCC} 557.1n 0 559n 0 559.1n {VCC} 561n {VCC} 561.1n
+0 563n 0 563.1n {VCC} 565n {VCC} 565.1n 0 567n 0 567.1n {VCC} 569n {VCC}
+569.1n 0 571n 0 571.1n {VCC} 573n {VCC} 573.1n 0 575n 0 575.1n {VCC} 577n
+{VCC} 577.1n 0 579n 0 579.1n {VCC} 581n {VCC} 581.1n 0 583n 0 583.1n {VCC}
+585n {VCC} 585.1n 0 587n 0 587.1n {VCC} 589n {VCC} 589.1n 0 591n 0 591.1n
+{VCC} 593n {VCC} 593.1n 0 595n 0 595.1n {VCC} 597n {VCC} 597.1n 0 599n 0
+599.1n {VCC} 601n {VCC} 601.1n 0 603n 0 603.1n {VCC} 605n {VCC} 605.1n 0 607n
+0 607.1n {VCC} 609n {VCC} 609.1n 0 611n 0 611.1n {VCC} 613n {VCC} 613.1n 0
+615n 0 615.1n {VCC} 617n {VCC} 617.1n 0 619n 0 619.1n {VCC} 621n {VCC} 621.1n
+0 623n 0 623.1n {VCC} 625n {VCC} 625.1n 0 627n 0 627.1n {VCC} 629n {VCC}
+629.1n 0 631n 0 631.1n {VCC} 633n {VCC} 633.1n 0 635n 0 635.1n {VCC} 637n
+{VCC} 637.1n 0 639n 0 639.1n {VCC} 641n {VCC} 641.1n 0 643n 0 643.1n {VCC}
+645n {VCC} 645.1n 0 647n 0 647.1n {VCC} 649n {VCC} 649.1n 0 651n 0 651.1n
+{VCC} 653n {VCC} 653.1n 0 655n 0 655.1n {VCC} 657n {VCC} 657.1n 0 659n 0
+659.1n {VCC} 661n {VCC} 661.1n 0 663n 0 663.1n {VCC} 665n {VCC} 665.1n 0 667n
+0 667.1n {VCC} 669n {VCC} 669.1n 0 671n 0 671.1n {VCC} 673n {VCC} 673.1n 0
+675n 0 675.1n {VCC} 677n {VCC} 677.1n 0 679n 0 679.1n {VCC} 681n {VCC} 681.1n
+0 683n 0 683.1n {VCC} 685n {VCC} 685.1n 0 687n 0 687.1n {VCC} 689n {VCC}
+689.1n 0 691n 0 691.1n {VCC} 693n {VCC} 693.1n 0 695n 0 695.1n {VCC} 697n
+{VCC} 697.1n 0 699n 0 699.1n {VCC} 701n {VCC} 701.1n 0 703n 0 703.1n {VCC}
+705n {VCC} 705.1n 0 707n 0 707.1n {VCC} 709n {VCC} 709.1n 0 711n 0 711.1n
+{VCC} 713n {VCC} 713.1n 0 715n 0 715.1n {VCC} 717n {VCC} 717.1n 0 719n 0
+719.1n {VCC} 721n {VCC} 721.1n 0 723n 0 723.1n {VCC} 725n {VCC} 725.1n 0 727n
+0 727.1n {VCC} 729n {VCC} 729.1n 0 731n 0 731.1n {VCC} 733n {VCC} 733.1n 0
+735n 0 735.1n {VCC} 737n {VCC} 737.1n 0 739n 0 739.1n {VCC} 741n {VCC} 741.1n
+0 743n 0 743.1n {VCC} 745n {VCC} 745.1n 0 747n 0 747.1n {VCC} 749n {VCC}
+749.1n 0 751n 0 751.1n {VCC} 753n {VCC} 753.1n 0 755n 0 755.1n {VCC} 757n
+{VCC} 757.1n 0 759n 0 759.1n {VCC} 761n {VCC} 761.1n 0 763n 0 763.1n {VCC}
+765n {VCC} 765.1n 0 767n 0 767.1n {VCC} 769n {VCC} 769.1n 0 771n 0 771.1n
+{VCC} 773n {VCC} 773.1n 0 775n 0 775.1n {VCC} 777n {VCC} 777.1n 0 779n 0
+779.1n {VCC} 781n {VCC} 781.1n 0 783n 0 783.1n {VCC} 785n {VCC} 785.1n 0 787n
+0 787.1n {VCC} 789n {VCC} 789.1n 0 791n 0 791.1n {VCC} 793n {VCC} 793.1n 0
+795n 0 795.1n {VCC} 797n {VCC} 797.1n 0 799n 0 799.1n {VCC} 801n {VCC} 801.1n
+0 803n 0 803.1n {VCC} 805n {VCC} 805.1n 0 807n 0 807.1n {VCC} 809n {VCC}
+809.1n 0 811n 0 811.1n {VCC} 813n {VCC} 813.1n 0 815n 0 815.1n {VCC} 817n
+{VCC} 817.1n 0 819n 0 819.1n {VCC} 821n {VCC} 821.1n 0 823n 0 823.1n {VCC}
+825n {VCC} 825.1n 0 827n 0 827.1n {VCC} 829n {VCC} 829.1n 0 831n 0 831.1n
+{VCC} 833n {VCC} 833.1n 0 835n 0 835.1n {VCC} 837n {VCC} 837.1n 0 839n 0
+839.1n {VCC} 841n {VCC} 841.1n 0 843n 0 843.1n {VCC} 845n {VCC} 845.1n 0 847n
+0 847.1n {VCC} 849n {VCC} 849.1n 0 851n 0 851.1n {VCC} 853n {VCC} 853.1n 0
+855n 0 855.1n {VCC} 857n {VCC} 857.1n 0 859n 0 859.1n {VCC} 861n {VCC} 861.1n
+0 863n 0 863.1n {VCC} 865n {VCC} 865.1n 0 867n 0 867.1n {VCC} 869n {VCC}
+869.1n 0 871n 0 871.1n {VCC} 873n {VCC} 873.1n 0 875n 0 875.1n {VCC} 877n
+{VCC} 877.1n 0 879n 0 879.1n {VCC} 881n {VCC} 881.1n 0 883n 0 883.1n {VCC}
+885n {VCC} 885.1n 0 887n 0 887.1n {VCC} 889n {VCC} 889.1n 0 891n 0 891.1n
+{VCC} 893n {VCC} 893.1n 0 895n 0 895.1n {VCC} 897n {VCC} 897.1n 0 899n 0
+899.1n {VCC} 901n {VCC} 901.1n 0 903n 0 903.1n {VCC} 905n {VCC} 905.1n 0 907n
+0 907.1n {VCC} 909n {VCC} 909.1n 0 911n 0 911.1n {VCC} 913n {VCC} 913.1n 0
+915n 0 915.1n {VCC} 917n {VCC} 917.1n 0 919n 0 919.1n {VCC} 921n {VCC} 921.1n
+0 923n 0 923.1n {VCC} 925n {VCC} 925.1n 0 927n 0 927.1n {VCC} 929n {VCC}
+929.1n 0 931n 0 931.1n {VCC} 933n {VCC} 933.1n 0 935n 0 935.1n {VCC} 937n
+{VCC} 937.1n 0 939n 0 939.1n {VCC} 941n {VCC} 941.1n 0 943n 0 943.1n {VCC}
+945n {VCC} 945.1n 0 947n 0 947.1n {VCC} 949n {VCC} 949.1n 0 951n 0 951.1n
+{VCC} 953n {VCC} 953.1n 0 955n 0 955.1n {VCC} 957n {VCC} 957.1n 0 959n 0
+959.1n {VCC} 961n {VCC} 961.1n 0 963n 0 963.1n {VCC} 965n {VCC} 965.1n 0 967n
+0 967.1n {VCC} 969n {VCC} 969.1n 0 971n 0 971.1n {VCC} 973n {VCC} 973.1n 0
+975n 0 975.1n {VCC} 977n {VCC} 977.1n 0 979n 0 979.1n {VCC} 981n {VCC} 981.1n
+0 983n 0 983.1n {VCC} 985n {VCC} 985.1n 0 987n 0 987.1n {VCC} 989n {VCC}
+989.1n 0 991n 0 991.1n {VCC} 993n {VCC} 993.1n 0 995n 0 995.1n {VCC} 997n
+{VCC} 997.1n 0 999n 0 999.1n {VCC} 1001n {VCC} 1001.1n 0 1003n 0 1003.1n {VCC}
+1005n {VCC} 1005.1n 0 1007n 0 1007.1n {VCC} 1009n {VCC} 1009.1n 0 1011n 0 1011.1n
+{VCC} 1013n {VCC} 1013.1n 0 1015n 0 1015.1n {VCC} 1017n {VCC} 1017.1n 0 1019n 0
+1019.1n {VCC} 1021n {VCC} 1021.1n 0 1023n 0 1023.1n {VCC}
VA[4] A[4] 0 PWL 1n 0 5n 0 5.1n {VCC} 9n {VCC} 9.1n 0 13n
+0 13.1n {VCC} 17n {VCC} 17.1n 0 21n 0 21.1n {VCC} 25n {VCC} 25.1n 0
+29n 0 29.1n {VCC} 33n {VCC} 33.1n 0 37n 0 37.1n {VCC} 41n {VCC} 41.1n
+0 45n 0 45.1n {VCC} 49n {VCC} 49.1n 0 53n 0 53.1n {VCC} 57n {VCC}
+57.1n 0 61n 0 61.1n {VCC} 65n {VCC} 65.1n 0 69n 0 69.1n {VCC} 73n
+{VCC} 73.1n 0 77n 0 77.1n {VCC} 81n {VCC} 81.1n 0 85n 0 85.1n {VCC}
+89n {VCC} 89.1n 0 93n 0 93.1n {VCC} 97n {VCC} 97.1n 0 101n 0 101.1n
+{VCC} 105n {VCC} 105.1n 0 109n 0 109.1n {VCC} 113n {VCC} 113.1n 0 117n 0
+117.1n {VCC} 121n {VCC} 121.1n 0 125n 0 125.1n {VCC} 129n {VCC} 129.1n 0 133n
+0 133.1n {VCC} 137n {VCC} 137.1n 0 141n 0 141.1n {VCC} 145n {VCC} 145.1n 0
+149n 0 149.1n {VCC} 153n {VCC} 153.1n 0 157n 0 157.1n {VCC} 161n {VCC} 161.1n
+0 165n 0 165.1n {VCC} 169n {VCC} 169.1n 0 173n 0 173.1n {VCC} 177n {VCC}
+177.1n 0 181n 0 181.1n {VCC} 185n {VCC} 185.1n 0 189n 0 189.1n {VCC} 193n
+{VCC} 193.1n 0 197n 0 197.1n {VCC} 201n {VCC} 201.1n 0 205n 0 205.1n {VCC}
+209n {VCC} 209.1n 0 213n 0 213.1n {VCC} 217n {VCC} 217.1n 0 221n 0 221.1n
+{VCC} 225n {VCC} 225.1n 0 229n 0 229.1n {VCC} 233n {VCC} 233.1n 0 237n 0
+237.1n {VCC} 241n {VCC} 241.1n 0 245n 0 245.1n {VCC} 249n {VCC} 249.1n 0 253n
+0 253.1n {VCC} 257n {VCC} 257.1n 0 261n 0 261.1n {VCC} 265n {VCC} 265.1n 0
+269n 0 269.1n {VCC} 273n {VCC} 273.1n 0 277n 0 277.1n {VCC} 281n {VCC} 281.1n
+0 285n 0 285.1n {VCC} 289n {VCC} 289.1n 0 293n 0 293.1n {VCC} 297n {VCC}
+297.1n 0 301n 0 301.1n {VCC} 305n {VCC} 305.1n 0 309n 0 309.1n {VCC} 313n
+{VCC} 313.1n 0 317n 0 317.1n {VCC} 321n {VCC} 321.1n 0 325n 0 325.1n {VCC}
+329n {VCC} 329.1n 0 333n 0 333.1n {VCC} 337n {VCC} 337.1n 0 341n 0 341.1n
+{VCC} 345n {VCC} 345.1n 0 349n 0 349.1n {VCC} 353n {VCC} 353.1n 0 357n 0
+357.1n {VCC} 361n {VCC} 361.1n 0 365n 0 365.1n {VCC} 369n {VCC} 369.1n 0 373n
+0 373.1n {VCC} 377n {VCC} 377.1n 0 381n 0 381.1n {VCC} 385n {VCC} 385.1n 0
+389n 0 389.1n {VCC} 393n {VCC} 393.1n 0 397n 0 397.1n {VCC} 401n {VCC} 401.1n
+0 405n 0 405.1n {VCC} 409n {VCC} 409.1n 0 413n 0 413.1n {VCC} 417n {VCC}
+417.1n 0 421n 0 421.1n {VCC} 425n {VCC} 425.1n 0 429n 0 429.1n {VCC} 433n
+{VCC} 433.1n 0 437n 0 437.1n {VCC} 441n {VCC} 441.1n 0 445n 0 445.1n {VCC}
+449n {VCC} 449.1n 0 453n 0 453.1n {VCC} 457n {VCC} 457.1n 0 461n 0 461.1n
+{VCC} 465n {VCC} 465.1n 0 469n 0 469.1n {VCC} 473n {VCC} 473.1n 0 477n 0
+477.1n {VCC} 481n {VCC} 481.1n 0 485n 0 485.1n {VCC} 489n {VCC} 489.1n 0 493n
+0 493.1n {VCC} 497n {VCC} 497.1n 0 501n 0 501.1n {VCC} 505n {VCC} 505.1n 0
+509n 0 509.1n {VCC} 513n {VCC} 513.1n 0 517n 0 517.1n {VCC} 521n {VCC} 521.1n
+0 525n 0 525.1n {VCC} 529n {VCC} 529.1n 0 533n 0 533.1n {VCC} 537n {VCC}
+537.1n 0 541n 0 541.1n {VCC} 545n {VCC} 545.1n 0 549n 0 549.1n {VCC} 553n
+{VCC} 553.1n 0 557n 0 557.1n {VCC} 561n {VCC} 561.1n 0 565n 0 565.1n {VCC}
+569n {VCC} 569.1n 0 573n 0 573.1n {VCC} 577n {VCC} 577.1n 0 581n 0 581.1n
+{VCC} 585n {VCC} 585.1n 0 589n 0 589.1n {VCC} 593n {VCC} 593.1n 0 597n 0
+597.1n {VCC} 601n {VCC} 601.1n 0 605n 0 605.1n {VCC} 609n {VCC} 609.1n 0 613n
+0 613.1n {VCC} 617n {VCC} 617.1n 0 621n 0 621.1n {VCC} 625n {VCC} 625.1n 0
+629n 0 629.1n {VCC} 633n {VCC} 633.1n 0 637n 0 637.1n {VCC} 641n {VCC} 641.1n
+0 645n 0 645.1n {VCC} 649n {VCC} 649.1n 0 653n 0 653.1n {VCC} 657n {VCC}
+657.1n 0 661n 0 661.1n {VCC} 665n {VCC} 665.1n 0 669n 0 669.1n {VCC} 673n
+{VCC} 673.1n 0 677n 0 677.1n {VCC} 681n {VCC} 681.1n 0 685n 0 685.1n {VCC}
+689n {VCC} 689.1n 0 693n 0 693.1n {VCC} 697n {VCC} 697.1n 0 701n 0 701.1n
+{VCC} 705n {VCC} 705.1n 0 709n 0 709.1n {VCC} 713n {VCC} 713.1n 0 717n 0
+717.1n {VCC} 721n {VCC} 721.1n 0 725n 0 725.1n {VCC} 729n {VCC} 729.1n 0 733n
+0 733.1n {VCC} 737n {VCC} 737.1n 0 741n 0 741.1n {VCC} 745n {VCC} 745.1n 0
+749n 0 749.1n {VCC} 753n {VCC} 753.1n 0 757n 0 757.1n {VCC} 761n {VCC} 761.1n
+0 765n 0 765.1n {VCC} 769n {VCC} 769.1n 0 773n 0 773.1n {VCC} 777n {VCC}
+777.1n 0 781n 0 781.1n {VCC} 785n {VCC} 785.1n 0 789n 0 789.1n {VCC} 793n
+{VCC} 793.1n 0 797n 0 797.1n {VCC} 801n {VCC} 801.1n 0 805n 0 805.1n {VCC}
+809n {VCC} 809.1n 0 813n 0 813.1n {VCC} 817n {VCC} 817.1n 0 821n 0 821.1n
+{VCC} 825n {VCC} 825.1n 0 829n 0 829.1n {VCC} 833n {VCC} 833.1n 0 837n 0
+837.1n {VCC} 841n {VCC} 841.1n 0 845n 0 845.1n {VCC} 849n {VCC} 849.1n 0 853n
+0 853.1n {VCC} 857n {VCC} 857.1n 0 861n 0 861.1n {VCC} 865n {VCC} 865.1n 0
+869n 0 869.1n {VCC} 873n {VCC} 873.1n 0 877n 0 877.1n {VCC} 881n {VCC} 881.1n
+0 885n 0 885.1n {VCC} 889n {VCC} 889.1n 0 893n 0 893.1n {VCC} 897n {VCC}
+897.1n 0 901n 0 901.1n {VCC} 905n {VCC} 905.1n 0 909n 0 909.1n {VCC} 913n
+{VCC} 913.1n 0 917n 0 917.1n {VCC} 921n {VCC} 921.1n 0 925n 0 925.1n {VCC}
+929n {VCC} 929.1n 0 933n 0 933.1n {VCC} 937n {VCC} 937.1n 0 941n 0 941.1n
+{VCC} 945n {VCC} 945.1n 0 949n 0 949.1n {VCC} 953n {VCC} 953.1n 0 957n 0
+957.1n {VCC} 961n {VCC} 961.1n 0 965n 0 965.1n {VCC} 969n {VCC} 969.1n 0 973n
+0 973.1n {VCC} 977n {VCC} 977.1n 0 981n 0 981.1n {VCC} 985n {VCC} 985.1n 0
+989n 0 989.1n {VCC} 993n {VCC} 993.1n 0 997n 0 997.1n {VCC} 1001n {VCC} 1001.1n
+0 1005n 0 1005.1n {VCC} 1009n {VCC} 1009.1n 0 1013n 0 1013.1n {VCC} 1017n {VCC}
+1017.1n 0 1021n 0 1021.1n {VCC}
VA[5] A[5] 0 PWL 1n 0 9n 0 9.1n {VCC} 17n {VCC} 17.1n 0 25n
+0 25.1n {VCC} 33n {VCC} 33.1n 0 41n 0 41.1n {VCC} 49n {VCC} 49.1n 0
+57n 0 57.1n {VCC} 65n {VCC} 65.1n 0 73n 0 73.1n {VCC} 81n {VCC} 81.1n
+0 89n 0 89.1n {VCC} 97n {VCC} 97.1n 0 105n 0 105.1n {VCC} 113n {VCC}
+113.1n 0 121n 0 121.1n {VCC} 129n {VCC} 129.1n 0 137n 0 137.1n {VCC} 145n
+{VCC} 145.1n 0 153n 0 153.1n {VCC} 161n {VCC} 161.1n 0 169n 0 169.1n {VCC}
+177n {VCC} 177.1n 0 185n 0 185.1n {VCC} 193n {VCC} 193.1n 0 201n 0 201.1n
+{VCC} 209n {VCC} 209.1n 0 217n 0 217.1n {VCC} 225n {VCC} 225.1n 0 233n 0
+233.1n {VCC} 241n {VCC} 241.1n 0 249n 0 249.1n {VCC} 257n {VCC} 257.1n 0 265n
+0 265.1n {VCC} 273n {VCC} 273.1n 0 281n 0 281.1n {VCC} 289n {VCC} 289.1n 0
+297n 0 297.1n {VCC} 305n {VCC} 305.1n 0 313n 0 313.1n {VCC} 321n {VCC} 321.1n
+0 329n 0 329.1n {VCC} 337n {VCC} 337.1n 0 345n 0 345.1n {VCC} 353n {VCC}
+353.1n 0 361n 0 361.1n {VCC} 369n {VCC} 369.1n 0 377n 0 377.1n {VCC} 385n
+{VCC} 385.1n 0 393n 0 393.1n {VCC} 401n {VCC} 401.1n 0 409n 0 409.1n {VCC}
+417n {VCC} 417.1n 0 425n 0 425.1n {VCC} 433n {VCC} 433.1n 0 441n 0 441.1n
+{VCC} 449n {VCC} 449.1n 0 457n 0 457.1n {VCC} 465n {VCC} 465.1n 0 473n 0
+473.1n {VCC} 481n {VCC} 481.1n 0 489n 0 489.1n {VCC} 497n {VCC} 497.1n 0 505n
+0 505.1n {VCC} 513n {VCC} 513.1n 0 521n 0 521.1n {VCC} 529n {VCC} 529.1n 0
+537n 0 537.1n {VCC} 545n {VCC} 545.1n 0 553n 0 553.1n {VCC} 561n {VCC} 561.1n
+0 569n 0 569.1n {VCC} 577n {VCC} 577.1n 0 585n 0 585.1n {VCC} 593n {VCC}
+593.1n 0 601n 0 601.1n {VCC} 609n {VCC} 609.1n 0 617n 0 617.1n {VCC} 625n
+{VCC} 625.1n 0 633n 0 633.1n {VCC} 641n {VCC} 641.1n 0 649n 0 649.1n {VCC}
+657n {VCC} 657.1n 0 665n 0 665.1n {VCC} 673n {VCC} 673.1n 0 681n 0 681.1n
+{VCC} 689n {VCC} 689.1n 0 697n 0 697.1n {VCC} 705n {VCC} 705.1n 0 713n 0
+713.1n {VCC} 721n {VCC} 721.1n 0 729n 0 729.1n {VCC} 737n {VCC} 737.1n 0 745n
+0 745.1n {VCC} 753n {VCC} 753.1n 0 761n 0 761.1n {VCC} 769n {VCC} 769.1n 0
+777n 0 777.1n {VCC} 785n {VCC} 785.1n 0 793n 0 793.1n {VCC} 801n {VCC} 801.1n
+0 809n 0 809.1n {VCC} 817n {VCC} 817.1n 0 825n 0 825.1n {VCC} 833n {VCC}
+833.1n 0 841n 0 841.1n {VCC} 849n {VCC} 849.1n 0 857n 0 857.1n {VCC} 865n
+{VCC} 865.1n 0 873n 0 873.1n {VCC} 881n {VCC} 881.1n 0 889n 0 889.1n {VCC}
+897n {VCC} 897.1n 0 905n 0 905.1n {VCC} 913n {VCC} 913.1n 0 921n 0 921.1n
+{VCC} 929n {VCC} 929.1n 0 937n 0 937.1n {VCC} 945n {VCC} 945.1n 0 953n 0
+953.1n {VCC} 961n {VCC} 961.1n 0 969n 0 969.1n {VCC} 977n {VCC} 977.1n 0 985n
+0 985.1n {VCC} 993n {VCC} 993.1n 0 1001n 0 1001.1n {VCC} 1009n {VCC} 1009.1n 0
+1017n 0 1017.1n {VCC}
VA[6] A[6] 0 PWL 1n 0 17n 0 17.1n {VCC} 33n {VCC} 33.1n 0 49n
+0 49.1n {VCC} 65n {VCC} 65.1n 0 81n 0 81.1n {VCC} 97n {VCC} 97.1n 0
+113n 0 113.1n {VCC} 129n {VCC} 129.1n 0 145n 0 145.1n {VCC} 161n {VCC} 161.1n
+0 177n 0 177.1n {VCC} 193n {VCC} 193.1n 0 209n 0 209.1n {VCC} 225n {VCC}
+225.1n 0 241n 0 241.1n {VCC} 257n {VCC} 257.1n 0 273n 0 273.1n {VCC} 289n
+{VCC} 289.1n 0 305n 0 305.1n {VCC} 321n {VCC} 321.1n 0 337n 0 337.1n {VCC}
+353n {VCC} 353.1n 0 369n 0 369.1n {VCC} 385n {VCC} 385.1n 0 401n 0 401.1n
+{VCC} 417n {VCC} 417.1n 0 433n 0 433.1n {VCC} 449n {VCC} 449.1n 0 465n 0
+465.1n {VCC} 481n {VCC} 481.1n 0 497n 0 497.1n {VCC} 513n {VCC} 513.1n 0 529n
+0 529.1n {VCC} 545n {VCC} 545.1n 0 561n 0 561.1n {VCC} 577n {VCC} 577.1n 0
+593n 0 593.1n {VCC} 609n {VCC} 609.1n 0 625n 0 625.1n {VCC} 641n {VCC} 641.1n
+0 657n 0 657.1n {VCC} 673n {VCC} 673.1n 0 689n 0 689.1n {VCC} 705n {VCC}
+705.1n 0 721n 0 721.1n {VCC} 737n {VCC} 737.1n 0 753n 0 753.1n {VCC} 769n
+{VCC} 769.1n 0 785n 0 785.1n {VCC} 801n {VCC} 801.1n 0 817n 0 817.1n {VCC}
+833n {VCC} 833.1n 0 849n 0 849.1n {VCC} 865n {VCC} 865.1n 0 881n 0 881.1n
+{VCC} 897n {VCC} 897.1n 0 913n 0 913.1n {VCC} 929n {VCC} 929.1n 0 945n 0
+945.1n {VCC} 961n {VCC} 961.1n 0 977n 0 977.1n {VCC} 993n {VCC} 993.1n 0 1009n
+0 1009.1n {VCC}
VA[7] A[7] 0 PWL 1n 0 33n 0 33.1n {VCC} 65n {VCC} 65.1n 0 97n
+0 97.1n {VCC} 129n {VCC} 129.1n 0 161n 0 161.1n {VCC} 193n {VCC} 193.1n 0
+225n 0 225.1n {VCC} 257n {VCC} 257.1n 0 289n 0 289.1n {VCC} 321n {VCC} 321.1n
+0 353n 0 353.1n {VCC} 385n {VCC} 385.1n 0 417n 0 417.1n {VCC} 449n {VCC}
+449.1n 0 481n 0 481.1n {VCC} 513n {VCC} 513.1n 0 545n 0 545.1n {VCC} 577n
+{VCC} 577.1n 0 609n 0 609.1n {VCC} 641n {VCC} 641.1n 0 673n 0 673.1n {VCC}
+705n {VCC} 705.1n 0 737n 0 737.1n {VCC} 769n {VCC} 769.1n 0 801n 0 801.1n
+{VCC} 833n {VCC} 833.1n 0 865n 0 865.1n {VCC} 897n {VCC} 897.1n 0 929n 0
+929.1n {VCC} 961n {VCC} 961.1n 0 993n 0 993.1n {VCC}
VA[8] A[8] 0 PWL 1n 0 65n 0 65.1n {VCC} 129n {VCC} 129.1n 0 193n
+0 193.1n {VCC} 257n {VCC} 257.1n 0 321n 0 321.1n {VCC} 385n {VCC} 385.1n 0
+449n 0 449.1n {VCC} 513n {VCC} 513.1n 0 577n 0 577.1n {VCC} 641n {VCC} 641.1n
+0 705n 0 705.1n {VCC} 769n {VCC} 769.1n 0 833n 0 833.1n {VCC} 897n {VCC}
+897.1n 0 961n 0 961.1n {VCC}
VA[10] A[10] 0 PWL 1n 0 257n 0 257.1n {VCC} 513n {VCC} 513.1n 0 769n
+0 769.1n {VCC}
VA[9] A[9] 0 PWL 1n 0 129n 0 129.1n {VCC} 257n {VCC} 257.1n 0 385n
+0 385.1n {VCC} 513n {VCC} 513.1n 0 641n 0 641.1n {VCC} 769n {VCC} 769.1n 0
+897n 0 897.1n {VCC}
VA[11] A[11] 0 PWL 1n 0 513n 0 513.1n {VCC}
