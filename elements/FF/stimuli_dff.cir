VVCC VCC 0 PWL 0n 0 1n 0 1.1n {VCC}
Vi_clk i_clk 0 PWL 0n 0 4n 0 4.1n {VCC} 6n {VCC} 6.1n 0 8n
+0 8.1n {VCC} 10n {VCC} 10.1n 0 12.2n 0 12.3n {VCC} 14.3n {VCC} 14.4n 0
+16.3n 0 16.4n {VCC} 18.3n {VCC} 18.4n 0 21.3n 0 21.4n {VCC} 23.3n {VCC} 23.4n
+0 25.3n 0 25.4n {VCC} 27.3n {VCC} 27.4n 0 29.5n 0 29.6n {VCC} 31.6n {VCC}
+31.7n 0 33.6n 0 33.7n {VCC} 35.6n {VCC} 35.7n 0
Vi_data i_data 0 PWL 0n 0 3n 0 3.1n {VCC} 6n {VCC} 6.1n 0 12n
+0 12.1n {VCC} 12.4n {VCC} 12.5n 0 20.3n 0 20.4n {VCC} 23.3n {VCC} 23.4n 0
+29.3n 0 29.4n {VCC} 29.7n {VCC} 29.8n 0
VVSS VSS 0 PWL 0n 0
