v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/media/FlexRV32/asic/elements/logic/nand_2.sym} 180 30 0 0 {name=x1}
C {/media/FlexRV32/asic/elements/xor.sym} 180 90 0 0 {name=x2}
C {/media/FlexRV32/asic/elements/logic/nor_2.sym} 200 160 0 0 {name=x3}
